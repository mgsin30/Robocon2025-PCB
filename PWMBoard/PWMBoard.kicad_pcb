# Repository mgsin30/Robocon2025-PCB (continued)

## KiCad design PowerBoard/PowerBoard.kicad_pcb (continued)

Parts:
C13: 0.5p; C_0603_1608Metric
C14, C18, C19, C32, C33: 0.1u; C_0603_1608Metric
C15, C17: 47n; C_0603_1608Metric
C16: 4.7n; C_0603_1608Metric
C20, C21, C22, C23, C24, C25: 1000u; CP_Radial_D12.5mm_P5.00mm
C26, C27, C28, C29, C30, C31: 4.7u; C_1206_3216Metric
C38: 4.7u; C_0603_1608Metric
D12, D13: D; D_SOD-123F
D14: EMG; LED_0603_1608Metric
D15: SOFT_EMG; LED_0603_1608Metric
D16: DIS; LED_0603_1608Metric
J7: EMG_EXSIG; PAコネクタ(2ピントップ型)
J8: PWR_SW; PAコネクタ(2ピントップ型)
J9: BTN1; PAコネクタ(2ピントップ型)
J10: BTN2; PAコネクタ(2ピントップ型)
J11: EMG_R; PAコネクタ(2ピントップ型)
JP3: OC_EN; PinHeader_1x03_P2.54mm_Vertical
JP4: PWR_SW_Alt; PinHeader_1x02_P2.54mm_Vertical
JP5: Btn_Alt1; PinHeader_1x02_P2.54mm_Vertical
JP6: Btn_Alt2; PinHeader_1x02_P2.54mm_Vertical
JP7: EMG_R_Alt; PinHeader_1x02_P2.54mm_Vertical
JP8: OC_SEL; PinHeader_1x03_P2.54mm_Vertical
K1: A31CxPxxVDC2
Q1: Q_NMOS; TO-252-2
R18: 42.7k; R_0603_1608Metric
R19: 390; R_0603_1608Metric
R20: 330; R_0603_1608Metric
R21, R22, R23, R26, R27, R29, R34, R35, R38: 10k; R_0603_1608Metric
R24, R25: 20; R_0603_1608Metric
R28, R30, R31, R33: 3.7k; R_0603_1608Metric
R32: 10; R_2512_6332Metric
R37: 71.5k; R_0603_1608Metric
RV1: 200k; 3362P
U7: MLX91221xxx-ABx-xxx-RE; SOIC-16W_7.5x10.3mm_P1.27mm
U8: UCC21550xDWR; SOIC-16W_7.5x10.3mm_P1.27mm
U9: Si7938DP; PowerPAK_SO-8_Dual
U10: VO615A; VO615A_Option7
U11: TLP7820; Toshiba_11-6B1A

Connections:
+3.3VD: C14.1, C15.1, R21.1, R22.1, R35.1, U7.14 (VDD), U8.3 (VCCI), U8.6 (DT), U8.8 (VCCI), U10.4; also elsewhere on the board
+5VA: C32.2, U11.1 (VDD1); also elsewhere on the board
+5VD: C33.1, U11.8 (VDD2); also elsewhere on the board
+12VA: C18.1, C19.1, U8.11 (VDDB), U8.16 (VDDA); also elsewhere on the board
+24VA: C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, K1.14 (87), R32.1, R33.1; also elsewhere on the board
+BATT: R18.1, U7.1 (IP+), U7.2 (IP+), U7.3 (IP+), U7.4 (IP+); also elsewhere on the board
/EMG/DISCHARGE: U8.2 (INB); also elsewhere on the board
/EMG/EMG_EXSIG: J7.1; also elsewhere on the board
/EMG/EMG_STATE: R29.1, U10.3; also elsewhere on the board
/EMG/IREF_SENSE: C17.1, R37.2, U7.10 (VREF); also elsewhere on the board
/EMG/I_SENSE: C16.1, R23.1, U7.12 (VOUT); also elsewhere on the board
/EMG/SOFT_EMG: U8.1 (INA); also elsewhere on the board
/EMG/V_SENSE: C38.1, R38.2; also elsewhere on the board
/EMG/Vin_SENSED: D12.2 (A), K1.11 (30), U7.5 (IP-), U7.6 (IP-), U7.7 (IP-), U7.8 (IP-); also elsewhere on the board
GNDA: C13.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.2, R19.2, R26.2, R27.2, R31.2, U8.9 (VSSB), U8.14 (VSSA), U9.1 (S1), U9.3 (S2), U10.2, U11.3 (IN-), U11.4 (GND1); also elsewhere on the board
GNDD: C14.2, C15.2, C16.2, C17.2, C38.2, J7.2, JP3.1 (A), Q1.3 (S), R23.2, R29.2, R34.2, RV1.3, U7.9 (VSS), U8.4 (GND), U11.5 (GND2); also elsewhere on the board
unnamed: D12.1 (K), D13.1 (K), K1.A1 (85)
unnamed: D13.2 (A), J8.1, JP4.2 (B), K1.A2 (86)
unnamed: D14.2 (A), J8.2, J9.1, JP4.1 (A), JP5.2 (B), R28.1
unnamed: D14.1 (K), R30.1
unnamed: D15.2 (A), J11.2, JP7.1 (A), R30.2, U9.5 (D1)
unnamed: D15.1 (K), R31.1
unnamed: D16.2 (A), R33.2
unnamed: D16.1 (K), R32.2, U9.6 (D2)
unnamed: J9.2, J10.1, JP5.1 (A), JP6.2 (B)
unnamed: J10.2, J11.1, JP6.1 (A), JP7.2 (B)
unnamed: JP3.3 (B), Q1.2 (D), R21.2
unnamed: JP3.2 (C), U8.5 (DIS)
unnamed: JP8.2 (C), R20.1
unnamed: Q1.1 (G), R20.2, R34.1
unnamed: R28.2, U10.1
unnamed: R37.1, RV1.1
unnamed: RV1.2, U7.15 (VOCEXT)
unnamed: R24.1, U8.15 (OUTA)
unnamed: R25.1, U8.10 (OUTB)
unnamed: R24.2, R27.1, U9.2 (G1)
unnamed: R25.2, R26.1, U9.4 (G2)
unnamed: C13.1, R18.2, R19.1, U11.2 (IN+)
unnamed: R38.1, U11.7 (OUT+)
OCDext: JP8.1 (A), R35.2, U7.13 (OCDEXT)
OCDint: JP8.3 (B), R22.2, U7.16 (OCDINT)

Notes on the sheet:
ボタン2
ボタンを接続しないならジャンパする
非常停止しているかどうかの確認用信号
通常時はHigh、過電流検出でLow
印加電圧：22V、検出電圧：200mV
外部からの非常停止要求信号
コイルの逆起電力保護用ダイオード
Highで無効化、Lowで有効化
ボタン1
High: 非常停止状態 Low: 通常状態

Board: 4 copper layers, 100.0 x 65.0 mm, 144 parts (52 on the bottom side), 87 nets.

File PowerBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BZ1,MagneticBuzzer_CUI_CMT-8504-100-SMT,1,Buzzer,
"C1, C2, C38, C6",0603,4,4.7u,
C10,0603,1,1u,
"C11, C12, C14, C18, C19, C3, C32, C33, C35, C37, C7, C8, C9",0603,13,0.1u,
C13,0603,1,0.5p,
"C15, C17",0603,2,47n,
C16,0603,1,4.7n,
"C20, C21, C22, C23, C24, C25",CP_Radial_D12.5mm_P5.00mm,6,1000u,
"C26, C27, C28, C29, C30, C31",1206,6,4.7u,
"C34, C36",0805,2,0.33u,
"C4, C5",0603,2,15p,
"D1, D11, D8, D9",0603,4,LED,
"D10, D2",Nexperia_CFP3_SOD-123W,2,D,
"D12, D13",D_SOD-123F,2,D,
D14,0603,1,EMG,
D15,0603,1,SOFT_EMG,
D16,0603,1,DIS,
D17,D_SMC_Handsoldering,1,D_TVS,
D18,D_SOD-323_HandSoldering,1,D_TVS,
D3,0603,1,PWR,
D4,0603,1,BATT,
D5,0603,1,24VA,
D6,D_SOD-128,1,D,
F1,MF-FSMF,1,Polyfuse,
F2,MF-USML_X,1,Polyfuse,
FB1,0603,1,FerriteBead,
J1,PAコネクタ(4ピントップ型),1,CAN,
J10,PAコネクタ(2ピントップ型),1,BTN2,
J11,PAコネクタ(2ピントップ型),1,EMG_R,
"J12, J3",AMASS_XT60-F_1x02_P7.20mm_Vertical,2,Vout,
J2,AMASS_XT60-M_1x02_P7.20mm_Vertical,1,Vin,
J4,USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal,1,Power,
J5,JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal,1,SWD,
J6,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,Debug,
J7,PAコネクタ(2ピントップ型),1,EMG_EXSIG,
J8,PAコネクタ(2ピントップ型),1,PWR_SW,
J9,PAコネクタ(2ピントップ型),1,BTN1,
K1,A31CxPxxVDC2,1,A31CxPxxVDC2,
Q1,TO-252-2,1,Q_NMOS,
R1,0603,1,420,
"R10, R11, R15, R16",0603,4,5.1k,
"R12, R21, R22, R23, R26, R27, R29, R34, R35, R36, R38",0603,11,10k,
"R13, R14, R17",0603,3,96,
R18,0603,1,42.7k,
R19,0603,1,390,
R2,0603,1,430,
R20,0603,1,330,
"R24, R25",0603,2,20,
"R28, R30, R31, R33",0603,4,3.7k,
"R3, R5",0603,2,1.5k,
R32,2512,1,10,
R37,0603,1,71.5k,
R4,0603,1,120,
R6,0603,1,100,
R7,0603,1,600,
R8,0603,1,300,
R9,0603,1,1k,
RV1,3362P,1,200k,
SW1,SLW,1,CAN_R,
SW2,TVAF06-A020B-R,1,Reset,
U1,SOT-223-3_TabPin2,1,TLV1117-33,
U10,VO615A_Option7,1,VO615A,
U11,Toshiba_11-6B1A,1,TLP7820,
U12,TO-252-2,1,NJM7812SDL1,
U13,TO-252-2,1,LM7805,
U2,LED_ROHM_SMLVN6,1,LED_GRB,
U3,RECxxK-AW,1,RECxxK-AW,
U4,LQFP-32_7x7mm_P0.8mm,1,STM32F303K8Tx,
U5,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2561/2FD,
U6,MSOP-10_3x3mm_P0.5mm,1,CH340E,
U7,SOIC-16W_7.5x10.3mm_P1.27mm,1,MLX91221xxx-ABx-xxx-RE,
U8,SOIC-16W_7.5x10.3mm_P1.27mm,1,UCC21550xDWR,
U9,PowerPAK_SO-8_Dual,1,Si7938DP,
Y1,XRCGB,1,Crystal_GND2,

## KiCad design RemoteEmergencyStopBoard/RemoteEmergencyStopBoard_RX/RemoteEmergencyStopBoard_RX.kicad_pcb

File RemoteEmergencyStopBoard/RemoteEmergencyStopBoard_RX/README.md:

# Remote Emergency Stop Board (RX)

遠隔非常停止の受信基板

## 変更履歴

### ver1.0 (完成日：2025/05/30)
- 初回完成

Parts:
C1: 10u; C_0805_2012Metric
D1: LED; LED_0603_1608Metric
D2: PWR; LED_0603_1608Metric
D3: ON; LED_0603_1608Metric
D4: D; D_SOD-123
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H5: MountingHole; Title
H6: MountingHole; Info_M
J1: PWR_IN; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J2: EMG_R; PAコネクタ(2ピントップ型)
JP1: OUT1; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP2: OUT2; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP3: OUT3; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP4: OUT4; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP5: NO/NC; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
K1: Relay_SPDT; J1031CxxVDC.xxS
Q1: Q_NMOS; TO-252-2
R1: 430; R_0603_1608Metric
R2: 10k; R_0603_1608Metric
R3: 420; R_0603_1608Metric
SW1: SET; CS1213AG
SW2: MODE; DS04-254-2-02BK-SMT
SW3: FREQ; DS04-254-2-02BK-SMT
SW4: PWR_SW; SS-12D00G3
U1: RRM-1A

Connections:
+5VA: D3.2 (A), D4.1 (K), J1.1, K1.A1, SW4.2 (B)
GNDA: C1.2, D1.1 (K), H1.1, H2.1, H3.1, H4.1, J1.2, Q1.3 (S), R1.2, R2.2, SW1.1, SW2.1, SW2.2, SW3.1, SW3.2, U1.2 (GND)
unnamed: D1.2 (A), U1.4 (LED)
unnamed: C1.1, D2.2 (A), SW4.1 (A), U1.1 (Vcc)
unnamed: D2.1 (K), R1.1
unnamed: D3.1 (K), R3.2
unnamed: D4.2 (A), K1.A2, Q1.2 (D), R3.1
unnamed: J2.1, K1.11
unnamed: J2.2, JP5.2 (C)
unnamed: JP1.1 (A), U1.8 (OUT1)
unnamed: JP1.2 (B), JP2.2 (B), JP3.2 (B), JP4.2 (B), Q1.1 (G), R2.1
unnamed: JP2.1 (A), U1.10 (OUT2)
unnamed: JP3.1 (A), U1.12 (OUT3)
unnamed: JP4.1 (A), U1.14 (OUT4)
unnamed: JP5.1 (A), K1.14
unnamed: JP5.3 (B), K1.12
unnamed: SW3.4, U1.11 (FREQ1)
unnamed: SW3.3, U1.13 (FREQ2)
unnamed: SW2.4, U1.5 (MODE1)
unnamed: SW2.3, U1.7 (MODE2)
unnamed: SW1.2, U1.3 (SET)

Board: 2 copper layers, 60.0 x 42.5 mm, 28 parts (10 on the bottom side), 21 nets.

File RemoteEmergencyStopBoard/RemoteEmergencyStopBoard_RX/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0805,1,10u,
D1,0603,1,LED,
D2,0603,1,PWR,
D3,0603,1,ON,
D4,D_SOD-123,1,D,
J1,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,PWR_IN,
J2,PAコネクタ(2ピントップ型),1,EMG_R,
K1,J1031CxxVDC.xxS,1,Relay_SPDT,
Q1,TO-252-2,1,Q_NMOS,
R1,0603,1,430,
R2,0603,1,10k,
R3,0603,1,420,
SW1,CS1213AG,1,SET,
SW2,DS04-254-2-02BK-SMT,1,MODE,
SW3,DS04-254-2-02BK-SMT,1,FREQ,
SW4,SS-12D00G3,1,PWR_SW,
U1,RRM-1A,1,RRM-1A,

## KiCad design RemoteEmergencyStopBoard/RemoteEmergencyStopBoard_TX/RemoteEmergencyStopBoard_TX.kicad_pcb

File RemoteEmergencyStopBoard/RemoteEmergencyStopBoard_TX/README.md:

# Remote Emergency Stop Board (TX)

遠隔非常停止の送信基板

## 変更履歴

### ver1.0 (完成日：2025/05/30)
- 初回完成

Parts:
C1: 10u; C_0805_2012Metric
D1, D2: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H5: MountingHole; Title
H6: MountingHole; Info_M
J1: BATT; PAコネクタ(2ピントップ型)
J2, J3: EMG; PAコネクタ(2ピントップ型)
JP1, JP2: OUT1; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP3, JP4: OUT2; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1, R2, R4, R5: 1k; R_0603_1608Metric
R3: 120; R_0603_1608Metric
SW1: PWR; SS-12D00G3
SW2: SW1; CS1213AG
SW3: SW3; CS1213AG
U1: RTM-1B

Connections:
+3V: J1.1, SW1.2 (B)
GNDA: C1.2, H1.1, H2.1, H3.1, H4.1, J1.2, J2.2, J3.2, R3.2, SW2.2, SW3.2, U1.7 (GND)
unnamed: C1.1, D1.2 (A), D2.2 (A), SW1.1 (A), U1.6 (Vcc)
unnamed: D1.1 (K), U1.5 (LED)
unnamed: D2.1 (K), R3.1
unnamed: J2.1, R1.2
unnamed: J3.1, R2.2
unnamed: JP1.1 (A), R4.1, U1.1 (SW1)
unnamed: JP1.2 (B), JP3.2 (B), R1.1
unnamed: JP2.1 (A), U1.2 (SW2)
unnamed: JP2.2 (B), JP4.2 (B), R2.1
unnamed: JP3.1 (A), R5.1, U1.3 (SW3)
unnamed: JP4.1 (A), U1.4 (SW4)
unnamed: R4.2, SW2.1
unnamed: R5.2, SW3.1

Board: 2 copper layers, 35.0 x 33.0 mm, 25 parts (7 on the bottom side), 15 nets.

File RemoteEmergencyStopBoard/RemoteEmergencyStopBoard_TX/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0805,1,10u,
"D1, D2",0603,2,LED,
J1,PAコネクタ(2ピントップ型),1,BATT,
"J2, J3",PAコネクタ(2ピントップ型),2,EMG,
"R1, R2, R4, R5",0603,4,1k,
R3,0603,1,120,
SW1,SS-12D00G3,1,PWR,
SW2,CS1213AG,1,SW1,
SW3,CS1213AG,1,SW3,
U1,RTM-1B,1,RTM-1B,

## KiCad design RoboMasterBoard/RoboMasterBoard.kicad_pcb

File RoboMasterBoard/README.md:

# RoboMaster Board

ロボマスモーターを制御するための基板

## 変更履歴

### ver1.0 (発注日：2025/04/12)
- 初回完成

### ver1.1 (発注日：2025/07/01)
- 未接続の箇所を修正
- 水晶発振子の型番を変更
- U2 のシルクの向きを変更
- 基板下部の取付穴を通常の穴に変更

Parts:
C1, C2: 4.7u; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9: LED; LED_0603_1608Metric
D14: D; Nexperia_CFP3_SOD-123W
D16: CAN_R; LED_0603_1608Metric
F1: Polyfuse; MF-FSMF
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J2: CAN1; IDC-Header_2x03_P2.54mm_Horizontal
J4: RM1; PAコネクタ(2ピンサイド型)
J5: RM2; PAコネクタ(2ピンサイド型)
J6: RM3; PAコネクタ(2ピンサイド型)
J7: RM4; PAコネクタ(2ピンサイド型)
J8: RM5; PAコネクタ(2ピンサイド型)
J9: RM6; PAコネクタ(2ピンサイド型)
J10: RM7; PAコネクタ(2ピンサイド型)
J11: RM8; PAコネクタ(2ピンサイド型)
R1, R2, R3, R4, R5, R6, R7, R8: 80; R_0603_1608Metric
R9: 430; R_0603_1608Metric
R15, R18, R19: 120; R_0603_1608Metric
R20: 100; R_0603_1608Metric
R21: 600; R_0603_1608Metric
R22: 300; R_0603_1608Metric
R24: 420; R_0603_1608Metric
SW2: CAN_R; SLW
SW3: SW_Coded; RDS-1055-SMT
U1: TLV1117-33; SOT-223-3_TabPin2
U5: LED_GRB; LED_ROHM_SMLVN6

Connections:
+3.3V: C2.1, U1.2 (VO); also elsewhere on the board
+5V: C1.1, D9.2 (A), D14.1 (K), D16.2 (A), U1.3 (VI); also elsewhere on the board
/CAN1/CAN_H: J2.3, R15.1; also elsewhere on the board
/CAN1/CAN_L: J2.4, SW2.1 (A); also elsewhere on the board
/CAN2/CAN_H: J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, R18.1, R19.1; also elsewhere on the board
/CAN2/CAN_L: J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, R18.2, R19.2; also elsewhere on the board
/MCU/ID1: SW3.2 (D0); also elsewhere on the board
/MCU/ID2: SW3.3 (D1); also elsewhere on the board
/MCU/ID3: SW3.4 (D2); also elsewhere on the board
/MCU/ID4: SW3.5 (D3); also elsewhere on the board
/MCU/LED1: R1.1; also elsewhere on the board
/MCU/LED2: R2.1; also elsewhere on the board
/MCU/LED3: R3.1; also elsewhere on the board
/MCU/LED4: R4.1; also elsewhere on the board
/MCU/LED5: R5.1; also elsewhere on the board
/MCU/LED6: R6.1; also elsewhere on the board
/MCU/LED7: R7.1; also elsewhere on the board
/MCU/LED8: R8.1; also elsewhere on the board
/MCU/LED_B: R20.2; also elsewhere on the board
/MCU/LED_G: R22.2; also elsewhere on the board
/MCU/LED_R: R21.2; also elsewhere on the board
GNDD: C1.2, C2.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), H1.1, H2.1, H3.1, H4.1, J2.5, J2.6, R9.2, SW2.4 (A), SW3.1 (CM), U1.1 (GND), U5.4, U5.5, U5.6; also elsewhere on the board
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.1 (K), R9.1
unnamed: D14.2 (A), F1.1
unnamed: D16.1 (K), R24.1
unnamed: F1.2, J2.1, J2.2
unnamed: R20.1, U5.1
unnamed: R21.1, U5.2
unnamed: R22.1, U5.3
unnamed: R15.2, SW2.2 (B)
unnamed: R24.2, SW2.5 (B)

Parts:
C15: 0.1u; C_0603_1608Metric
D12: CAN_TX; LED_0603_1608Metric
D13: CAN_RX; LED_0603_1608Metric
JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R13, R14: 96; R_0603_1608Metric
U4: MCP2561/2FD; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C15.1, JP2.2 (B), U4.3 (VDD); also elsewhere on the board
/CAN2/CAN_H: U4.7 (CANH); also elsewhere on the board
/CAN2/CAN_L: U4.6 (CANL); also elsewhere on the board
/CAN2/CAN_RX: D13.2 (A), U4.4 (RXD); also elsewhere on the board
/CAN2/CAN_TX: D12.2 (A), U4.1 (TXD); also elsewhere on the board
GNDD: C15.2, R13.2, R14.2, U4.2 (VSS), U4.8 (STBY); also elsewhere on the board
unnamed: D12.1 (K), R13.1
unnamed: D13.1 (K), R14.1
unnamed: JP2.1 (A), U4.5 (VIO)

Parts:
C14: 0.1u; C_0603_1608Metric
D10: CAN_TX; LED_0603_1608Metric
D11: CAN_RX; LED_0603_1608Metric
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R11, R12: 96; R_0603_1608Metric
U3: MCP2561/2FD; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C14.1, JP1.2 (B), U3.3 (VDD); also elsewhere on the board
/CAN1/CAN_H: U3.7 (CANH); also elsewhere on the board
/CAN1/CAN_L: U3.6 (CANL); also elsewhere on the board
/CAN1/CAN_RX: D11.2 (A), U3.4 (RXD); also elsewhere on the board
/CAN1/CAN_TX: D10.2 (A), U3.1 (TXD); also elsewhere on the board
GNDD: C14.2, R11.2, R12.2, U3.2 (VSS), U3.8 (STBY); also elsewhere on the board
unnamed: D10.1 (K), R11.1
unnamed: D11.1 (K), R12.1
unnamed: JP1.1 (A), U3.5 (VIO)

Parts:
D15: D; Nexperia_CFP3_SOD-123W
F2: Polyfuse; MF-FSMF
J3: Debug; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R16, R17: 5.1k; R_0603_1608Metric

Connections:
+5V: D15.1 (K); also elsewhere on the board
/MCU/USB_D+: J3.A6 (D+), J3.B6 (D+); also elsewhere on the board
/MCU/USB_D-: J3.A7 (D-), J3.B7 (D-); also elsewhere on the board
GNDD: J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), R16.2, R17.2; also elsewhere on the board
unnamed: D15.2 (A), F2.1
unnamed: F2.2, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
unnamed: J3.A5 (CC1), R16.1
unnamed: J3.B5 (CC2), R17.1
