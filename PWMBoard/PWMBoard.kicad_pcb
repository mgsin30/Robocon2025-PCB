# Repository mgsin30/Robocon2025-PCB (continued)

## KiCad design RoboMasterBoard/RoboMasterBoard.kicad_pcb (continued)

Parts:
C3, C4, C5, C6, C8, C12: 0.1u; C_0603_1608Metric
C7, C13: 4.7u; C_0603_1608Metric
C9: 1u; C_0603_1608Metric
C10, C11: 15p; C_0603_1608Metric
FB1: FerriteBead; L_0603_1608Metric
J1: SWD; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
R10: 10k; R_0603_1608Metric
R23: 10k; R_0603_1608Metric; not fitted
SW1: RESET; TVAF06-A020B-R
U2: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
Y1: Crystal_GND2; XRCGB

Connections:
+3.3V: C3.1, C4.1, C5.1, C6.1, C7.1, FB1.1, R23.1, U2.1 (VBAT), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD); also elsewhere on the board
+3.3VADC: C8.1, C9.1, FB1.2, U2.13 (VDDA)
/CAN1/CAN_RX: U2.61 (PB8); also elsewhere on the board
/CAN1/CAN_TX: U2.62 (PB9); also elsewhere on the board
/CAN2/CAN_RX: U2.57 (PB5); also elsewhere on the board
/CAN2/CAN_TX: U2.58 (PB6); also elsewhere on the board
/MCU/ID1: U2.8 (PC0); also elsewhere on the board
/MCU/ID2: U2.10 (PC2); also elsewhere on the board
/MCU/ID3: U2.9 (PC1); also elsewhere on the board
/MCU/ID4: U2.11 (PC3); also elsewhere on the board
/MCU/LED1: U2.27 (PB1); also elsewhere on the board
/MCU/LED2: U2.26 (PB0); also elsewhere on the board
/MCU/LED3: U2.23 (PA7); also elsewhere on the board
/MCU/LED4: U2.22 (PA6); also elsewhere on the board
/MCU/LED5: U2.21 (PA5); also elsewhere on the board
/MCU/LED6: U2.17 (PA3); also elsewhere on the board
/MCU/LED7: U2.16 (PA2); also elsewhere on the board
/MCU/LED8: U2.15 (PA1); also elsewhere on the board
/MCU/LED_B: U2.41 (PA8); also elsewhere on the board
/MCU/LED_G: U2.43 (PA10); also elsewhere on the board
/MCU/LED_R: U2.42 (PA9); also elsewhere on the board
/MCU/NRST: C12.1, J1.4, SW1.2, U2.7 (NRST)
/MCU/SWCLK: J1.2, U2.49 (PA14)
/MCU/SWDIO: J1.1, U2.46 (PA13)
/MCU/USB_D+: U2.45 (PA12); also elsewhere on the board
/MCU/USB_D-: U2.44 (PA11); also elsewhere on the board
GNDD: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J1.3, R10.2, SW1.1, U2.12 (VSSA), U2.18 (VSS), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS); also elsewhere on the board
unnamed: R10.1, R23.2, U2.60 (BOOT0)
unnamed: C10.1, U2.5 (PH0), Y1.1
unnamed: C11.1, U2.6 (PH1), Y1.3
unnamed: C13.1, U2.30 (VCAP_1)

Notes on the sheet:
ESR: 1Ω未満
LED8: PA1: TIM2_CH2 LED7: PA2: TIM2_CH3 LED6: PA3: TIM2_CH4 LED5: PA5: TIM2_CH1 LED4: PA6: TIM3_CH1 LED3: PA7: TIM3_CH2 LED2: PB0: TIM3_CH3 LED1: PB1: TIM3_CH4 LED_R: PA8: TIM1_CH1 LED_G: PA9: TIM1_CH2 LED_B: PA10: TIM1_CH3 CAN1: メインバス CAN1_TX: PA12 CAN1_RX: PA11 CAN2: ロボマス CAN2_TX: PB5 CAN2_RX: PB6

Board: 2 copper layers, 70.0 x 45.0 mm, 84 parts (3 on the bottom side), 63 nets.

File RoboMasterBoard/bom/RoboMasterBoard.csv:

"Reference","Qty","Value","Name","URL","Price"
"C1","1","4.7u","GRM188R60J226MEA0D","https://www.digikey.jp/ja/products/detail/murata-electronics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","30"
"C2,C7,C13","3","4.7u","GRM188R60G106ME47D","https://www.digikey.jp/ja/products/detail/murata-electronics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","19"
"C3,C4,C5,C6,C8,C12,C14,C15","8","0.1u","GCJ188R91H124KA01D","https://www.digikey.jp/ja/products/detail/murata-electronics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","36"
"C9","1","1u","GRM188D71H105ME01W","https://www.digikey.jp/ja/products/detail/murata-electronics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","47"
"C10,C11","2","15p","GCM1885C2A150JA16D","https://www.digikey.jp/ja/products/detail/murata-electronics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","16"
"D1,D2,D3,D4,D5,D6,D7,D8,D16","9","CAN_R,LED","SMLD12BN1WT86","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","48"
"D9","1","LED","SML-D12D8WT86","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","30"
"D10,D11,D12,D13","4","CAN_RX,CAN_TX","SML-D14MWT86A","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","53"
"D14,D15","2","D","PMEG3010ER,115","https://www.digikey.jp/ja/products/detail/nexperia-usa-inc/P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 ","30"
"F1,F2","2","Polyfuse","MF-FSMF020X-2","https://akizukidenshi.com/catalog/g/g114311/","20"
"FB1","1","FerriteBead","BLM18KG601SN1D","https://www.digikey.jp/ja/products/detail/murata-electronics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","16"
"J1","1","SWD","SM04B-SRSS-TB","https://www.digikey.jp/ja/products/detail/jst-sales-america-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","81"
"J2","1","CAN1","JS-1200R-06","https://eleshop.jp/shop/g/g7AB411/","62"
"J3","1","Debug","5077CR-16-SMC2-BK-TR","https://akizukidenshi.com/catalog/g/g114356/","110"
"J4,J5,J6,J7,J8,J9,J10,J11","8","RM1,RM2,RM3,RM4,RM5,RM6,RM7,RM8","S02B-PASK-2","https://www.digikey.jp/ja/products/detail/jst-sales-america-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","41"
"R1,R2,R3,R4,R5,R6,R7,R8","8","80","ESR03EZPJ820","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","22"
"R9,R24","2","420,430","ESR03EZPJ431","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","22"
"R10,R23","2","10k","ESR03EZPJ103","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","22"
"R11,R12,R13,R14,R20","5","100,96","ESR03EZPJ101","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","22"
"R15,R18,R19","3","120","ESR03EZPJ121","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","22"
"R16,R17","2","5.1k","ESR03EZPJ512","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","22"
"R21","1","600","ESR03EZPF5900","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","22"
"R22","1","300","ESR03EZPJ301","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","22"
"SW1","1","RESET","TVAF06-A020B-R","https://akizukidenshi.com/catalog/g/g114888/","22"
"SW2","1","CAN_R","SLW-913535-2A-SMT","https://www.digikey.jp/ja/products/detail/same-sky-formerly-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","87"
"SW3","1","SW_Coded","RDS-16S-1055-SMT-TR","https://www.digikey.jp/ja/products/detail/same-sky-formerly-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","458"
"U1","1","TLV1117-33","TLV1117-33CDCYR","https://www.digikey.jp/ja/products/detail/texas-instruments/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","63"
"U2","1","STM32F446RETx","STM32F446RET6","https://www.digikey.jp/ja/products/detail/stmicroelectronics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","1348"
"U3,U4","2","MCP2561/2FD","MCP2562FDT-E/SN","https://www.digikey.jp/ja/products/detail/microchip-technolo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","202"
"U5","1","LED_GRB","SMLVN6RGB1W1","https://www.digikey.jp/ja/products/detail/rohm-semiconductor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","244"
"Y1","1","Crystal_GND2","XRCGB26M000F1SADR0","https://www.digikey.jp/ja/products/detail/murata-electronics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","50"

## KiCad design SolenoidDriver/SolenoidDriver.kicad_pcb

File SolenoidDriver/README.md:

# Solenoid Driver

ソレノイドやソレノイドバルブを制御するための基板

## 変更履歴

### ver1.0 (発注日：2025/04/12)
- 初回完成

### ver1.1 (発注日：2025/07/01)
- 電源コネクタの接続が逆になっていたのを修正
- ソレノイド接続部に電流制限抵抗を追加
- 基板下部の取付穴を通常の穴に変更
- コネクタ部のシルクのサイズを微調整

Parts:
C1, C2: 4.7u; C_0603_1608Metric
D1, D15: LED; LED_0603_1608Metric
D6: D; Nexperia_CFP3_SOD-123W
D16: SOL1A; LED_0603_1608Metric
D17: SOL1B; LED_0603_1608Metric
D18: SOL2A; LED_0603_1608Metric
D19: SOL2B; LED_0603_1608Metric
D20: SOL3A; LED_0603_1608Metric
D21: SOL3B; LED_0603_1608Metric
D22: SOL4A; LED_0603_1608Metric
D23: SOL4B; LED_0603_1608Metric
D24: CAN_R; LED_0603_1608Metric
F2: Polyfuse; MF-FSMF
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H5: MountingHole; Title
H6: MountingHole; Aho_old_M
H7: MountingHole; Aho_new_M
H8: MountingHole; Info_M
J3: CAN; IDC-Header_2x03_P2.54mm_Horizontal
J4: SOL1A; PAコネクタ(2ピンサイド型)
J5: SOL1B; PAコネクタ(2ピンサイド型)
J6: SOL2A; PAコネクタ(2ピンサイド型)
J7: SOL2B; PAコネクタ(2ピンサイド型)
J8: SOL3A; PAコネクタ(2ピンサイド型)
J9: SOL3B; PAコネクタ(2ピンサイド型)
J10: SOL4A; PAコネクタ(2ピンサイド型)
J11: SOL4B; PAコネクタ(2ピンサイド型)
J12: BATT; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
R1: 430; R_0603_1608Metric
R7: 120; R_0603_1608Metric
R8: 100; R_0603_1608Metric
R9: 600; R_0603_1608Metric
R10: 300; R_0603_1608Metric
R51: 1.5k; R_0603_1608Metric
R52: 420; R_0603_1608Metric
R53, R54, R55, R56, R57, R58, R59, R60: 80; R_0603_1608Metric
SW2: CAN_R; SLW
SW3: SW_Coded; RDS-1055-SMT
U1: TLV1117-33; SOT-223-3_TabPin2
U5: LED_GRB; LED_ROHM_SMLVN6

Connections:
+3.3V: C2.1, U1.2 (VO); also elsewhere on the board
+5V: C1.1, D1.2 (A), D6.1 (K), D24.2 (A), U1.3 (VI); also elsewhere on the board
+BATT: D15.2 (A), J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.2; also elsewhere on the board
/CAN/CAN_H: J3.3, R7.1; also elsewhere on the board
/CAN/CAN_L: J3.4, SW2.1 (A); also elsewhere on the board
/Isolator/SOL1A: D16.2 (A); also elsewhere on the board
/Isolator/SOL1B: D17.2 (A); also elsewhere on the board
/Isolator/SOL2A: D18.2 (A); also elsewhere on the board
/Isolator/SOL2B: D19.2 (A); also elsewhere on the board
/Isolator/SOL3A: D20.2 (A); also elsewhere on the board
/Isolator/SOL3B: D21.2 (A); also elsewhere on the board
/Isolator/SOL4A: D22.2 (A); also elsewhere on the board
/Isolator/SOL4B: D23.2 (A); also elsewhere on the board
/MCU/ID0: SW3.2 (D0); also elsewhere on the board
/MCU/ID1: SW3.3 (D1); also elsewhere on the board
/MCU/ID2: SW3.4 (D2); also elsewhere on the board
/MCU/ID3: SW3.5 (D3); also elsewhere on the board
/MCU/LED_B: R8.2; also elsewhere on the board
/MCU/LED_G: R10.2; also elsewhere on the board
/MCU/LED_R: R9.2; also elsewhere on the board
/MOSFET/SOL1A-: J4.2; also elsewhere on the board
/MOSFET/SOL1B-: J5.2; also elsewhere on the board
/MOSFET/SOL2A-: J6.2; also elsewhere on the board
/MOSFET/SOL2B-: J7.2; also elsewhere on the board
/MOSFET/SOL3A-: J8.2; also elsewhere on the board
/MOSFET/SOL3B-: J9.2; also elsewhere on the board
/MOSFET/SOL4A-: J10.2; also elsewhere on the board
/MOSFET/SOL4B-: J11.2; also elsewhere on the board
GNDA: H2.1, H4.1, J12.1, R51.2; also elsewhere on the board
GNDD: C1.2, C2.2, H1.1, H3.1, J3.5, J3.6, R1.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, SW2.4 (A), SW3.1 (CM), U1.1 (GND), U5.4, U5.5, U5.6; also elsewhere on the board
unnamed: D1.1 (K), R1.1
unnamed: D6.2 (A), F2.1
unnamed: D15.1 (K), R51.1
unnamed: D16.1 (K), R53.1
unnamed: D17.1 (K), R54.1
unnamed: D18.1 (K), R55.1
unnamed: D19.1 (K), R56.1
unnamed: D20.1 (K), R57.1
unnamed: D21.1 (K), R58.1
unnamed: D22.1 (K), R59.1
unnamed: D23.1 (K), R60.1
unnamed: D24.1 (K), R52.1
unnamed: F2.2, J3.1, J3.2
unnamed: R8.1, U5.1
unnamed: R9.1, U5.2
unnamed: R10.1, U5.3
unnamed: R7.2, SW2.2 (B)
unnamed: R52.2, SW2.5 (B)

Parts:
R13, R14, R15, R16, R17, R18, R19, R20: 205; R_0603_1608Metric
U6, U7: TLP293-4; SOIC-16_4.55x10.3mm_P1.27mm

Connections:
+BATT: U6.10, U6.12, U6.14, U6.16, U7.10, U7.12, U7.14, U7.16; also elsewhere on the board
/Isolator/SOL1A: R13.1; also elsewhere on the board
/Isolator/SOL1AA: U6.15; also elsewhere on the board
/Isolator/SOL1B: R14.1; also elsewhere on the board
/Isolator/SOL1BA: U6.13; also elsewhere on the board
/Isolator/SOL2A: R15.1; also elsewhere on the board
/Isolator/SOL2AA: U6.11; also elsewhere on the board
/Isolator/SOL2B: R16.1; also elsewhere on the board
/Isolator/SOL2BA: U6.9; also elsewhere on the board
/Isolator/SOL3A: R17.1; also elsewhere on the board
/Isolator/SOL3AA: U7.15; also elsewhere on the board
/Isolator/SOL3B: R18.1; also elsewhere on the board
/Isolator/SOL3BA: U7.13; also elsewhere on the board
/Isolator/SOL4A: R19.1; also elsewhere on the board
/Isolator/SOL4AA: U7.11; also elsewhere on the board
/Isolator/SOL4B: R20.1; also elsewhere on the board
/Isolator/SOL4BA: U7.9; also elsewhere on the board
GNDD: U6.2, U6.4, U6.6, U6.8, U7.2, U7.4, U7.6, U7.8; also elsewhere on the board
unnamed: R13.2, U6.1
unnamed: R14.2, U6.3
unnamed: R15.2, U6.5
unnamed: R16.2, U6.7
unnamed: R17.2, U7.1
unnamed: R18.2, U7.3
unnamed: R19.2, U7.5
unnamed: R20.2, U7.7

Notes on the sheet:
SOL3
SOL4
SOL2
SOL1

Parts:
C11: 0.1u; C_0603_1608Metric
D2: CAN_TX; LED_0603_1608Metric
D3: CAN_RX; LED_0603_1608Metric
JP1: MCP2561/2FD selector; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R3, R4: 96; R_0603_1608Metric
U3: MCP2561/2FD; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C11.1, JP1.2 (B), U3.3 (VDD); also elsewhere on the board
/CAN/CAN_H: U3.7 (CANH); also elsewhere on the board
/CAN/CAN_L: U3.6 (CANL); also elsewhere on the board
/CAN/CAN_RX: D3.2 (A), U3.4 (RXD); also elsewhere on the board
/CAN/CAN_TX: D2.2 (A), U3.1 (TXD); also elsewhere on the board
GNDD: C11.2, R3.2, R4.2, U3.2 (VSS), U3.8 (STBY); also elsewhere on the board
unnamed: D2.1 (K), R3.1
unnamed: D3.1 (K), R4.1
unnamed: JP1.1 (A), U3.5 (VIO)

Notes on the sheet:
MCP2562FDを使うならジャンパする

Parts:
C12: 0.1u; C_0603_1608Metric
D4: D; Nexperia_CFP3_SOD-123W
D5: Data; LED_0603_1608Metric
F1: Polyfuse; MF-FSMF
J2: Debug; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R5, R6: 5.1k; R_0603_1608Metric
R12: 96; R_0603_1608Metric
U4: CH340E; MSOP-10_3x3mm_P0.5mm

Connections:
+3.3V: C12.1, U4.7 (VCC), U4.10 (V3); also elsewhere on the board
+5V: D4.1 (K); also elsewhere on the board
/MCU/UART2_RX: U4.8 (TXD); also elsewhere on the board
/MCU/UART2_TX: U4.9 (RXD); also elsewhere on the board
GNDD: C12.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), R5.2, R6.2, R12.2, U4.3 (GND); also elsewhere on the board
unnamed: D4.2 (A), F1.1
unnamed: D5.2 (A), U4.6 (TNOW)
unnamed: D5.1 (K), R12.1
unnamed: F1.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: J2.A5 (CC1), R6.1
unnamed: J2.B5 (CC2), R5.1
unnamed: J2.A6 (D+), J2.B6 (D+), U4.1 (UD+)
unnamed: J2.A7 (D-), J2.B7 (D-), U4.2 (UD-)

Parts:
D7, D8, D9, D10, D11, D12, D13, D14: D; D_SOD-123
Q1, Q2, Q3, Q4: Q_Dual_NMOS; Infineon_PG-DSO-8-24_4x5mm
R21, R23, R25, R27, R29, R31, R32, R33: 50; R_0603_1608Metric
R22, R24, R26, R28, R30, R34, R35, R36: 10k; R_0603_1608Metric
R37, R38, R39, R40, R41, R42, R43, R44: 20; R_0603_1608Metric

Connections:
+BATT: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K); also elsewhere on the board
/Isolator/SOL1AA: R21.1; also elsewhere on the board
/Isolator/SOL1BA: R23.1; also elsewhere on the board
/Isolator/SOL2AA: R25.1; also elsewhere on the board
/Isolator/SOL2BA: R27.1; also elsewhere on the board
/Isolator/SOL3AA: R29.1; also elsewhere on the board
/Isolator/SOL3BA: R31.1; also elsewhere on the board
/Isolator/SOL4AA: R32.1; also elsewhere on the board
/Isolator/SOL4BA: R33.1; also elsewhere on the board
/MOSFET/SOL1A-: D7.2 (A), R37.1; also elsewhere on the board
/MOSFET/SOL1B-: D8.2 (A), R38.1; also elsewhere on the board
/MOSFET/SOL2A-: D9.2 (A), R39.1; also elsewhere on the board
/MOSFET/SOL2B-: D10.2 (A), R40.1; also elsewhere on the board
/MOSFET/SOL3A-: D11.2 (A), R41.1; also elsewhere on the board
/MOSFET/SOL3B-: D12.2 (A), R42.1; also elsewhere on the board
/MOSFET/SOL4A-: D13.2 (A), R43.1; also elsewhere on the board
/MOSFET/SOL4B-: D14.2 (A), R44.1; also elsewhere on the board
GNDA: Q1.1 (S), Q1.3 (S), Q2.1 (S), Q2.3 (S), Q3.1 (S), Q3.3 (S), Q4.1 (S), Q4.3 (S), R22.2, R24.2, R26.2, R28.2, R30.2, R34.2, R35.2, R36.2; also elsewhere on the board
unnamed: Q1.7 (D), Q1.8 (D), R37.2
unnamed: Q1.2 (G), R21.2, R22.1
unnamed: Q1.5 (D), Q1.6 (D), R38.2
unnamed: Q1.4 (G), R23.2, R24.1
unnamed: Q2.7 (D), Q2.8 (D), R39.2
unnamed: Q2.2 (G), R25.2, R26.1
unnamed: Q2.5 (D), Q2.6 (D), R40.2
unnamed: Q2.4 (G), R27.2, R28.1
unnamed: Q3.7 (D), Q3.8 (D), R41.2
unnamed: Q3.2 (G), R29.2, R30.1
unnamed: Q3.5 (D), Q3.6 (D), R42.2
unnamed: Q3.4 (G), R31.2, R34.1
unnamed: Q4.7 (D), Q4.8 (D), R43.2
unnamed: Q4.2 (G), R32.2, R35.1
unnamed: Q4.5 (D), Q4.6 (D), R44.2
unnamed: Q4.4 (G), R33.2, R36.1

Notes on the sheet:
SOL3
SOL1
SOL2
SOL4

Parts:
C3, C4, C6, C8: 0.1u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C7: 1u; C_0603_1608Metric
C9, C10: 15p; C_0603_1608Metric
FB1: FerriteBead; L_0603_1608Metric
J1: SWD; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
R2: 10k; R_0603_1608Metric
R11: 10k; R_0603_1608Metric; not fitted
SW1: Reset; TVAF06-A020B-R
U2: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
Y1: Crystal_GND2; XRCGB

Connections:
+3.3V: C3.1, C4.1, C5.1, FB1.1, R11.1, U2.1 (VDD), U2.17 (VDD); also elsewhere on the board
+3.3VADC: C6.1, C7.1, FB1.2, U2.5 (VDDA)
/CAN/CAN_RX: U2.21 (PA11); also elsewhere on the board
/CAN/CAN_TX: U2.22 (PA12); also elsewhere on the board
/Isolator/SOL1A: U2.15 (PB1); also elsewhere on the board
/Isolator/SOL1B: U2.14 (PB0); also elsewhere on the board
/Isolator/SOL2A: U2.13 (PA7); also elsewhere on the board
/Isolator/SOL2B: U2.12 (PA6); also elsewhere on the board
/Isolator/SOL3A: U2.11 (PA5); also elsewhere on the board
/Isolator/SOL3B: U2.10 (PA4); also elsewhere on the board
/Isolator/SOL4A: U2.8 (PA2); also elsewhere on the board
/Isolator/SOL4B: U2.7 (PA1); also elsewhere on the board
/MCU/ID0: U2.27 (PB4); also elsewhere on the board
/MCU/ID1: U2.29 (PB6); also elsewhere on the board
/MCU/ID2: U2.28 (PB5); also elsewhere on the board
/MCU/ID3: U2.30 (PB7); also elsewhere on the board
/MCU/LED_B: U2.18 (PA8); also elsewhere on the board
/MCU/LED_G: U2.20 (PA10); also elsewhere on the board
/MCU/LED_R: U2.19 (PA9); also elsewhere on the board
/MCU/NRST: C8.1, J1.4, SW1.2, U2.4 (NRST)
/MCU/SWCLK: J1.2, U2.24 (PA14)
/MCU/SWDIO: J1.1, U2.23 (PA13)
/MCU/UART2_RX: U2.25 (PA15); also elsewhere on the board
/MCU/UART2_TX: U2.26 (PB3); also elsewhere on the board
GNDD: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J1.3, R2.2, SW1.1, U2.16 (VSS), U2.32 (VSS); also elsewhere on the board
unnamed: R2.1, R11.2, U2.31 (BOOT0)
unnamed: C9.1, U2.2 (PF0), Y1.1
unnamed: C10.1, U2.3 (PF1), Y1.3

Notes on the sheet:
LED_R: TIM1_CH1 LED_G: TIM1_CH2 LED_B: TIM1_CH3
