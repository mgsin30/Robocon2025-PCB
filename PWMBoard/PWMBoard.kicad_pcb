# Repository mgsin30/Robocon2025-PCB

## KiCad design PWMBoard/PWMBoard.kicad_pcb

Parts:
C1, C2: 4.7u; C_0603_1608Metric
C13, C14: 0.1u; C_0603_1608Metric
D1, D7, D8, D9, D10, D11, D12, D13, D14, D15, D17: LED; LED_0603_1608Metric
D6, D16: D; Nexperia_CFP3_SOD-123W
F2: Polyfuse; MF-FSMF
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J3: CAN; IDC-Header_2x03_P2.54mm_Horizontal
J4, J5, J6, J7, J8, J9, J10, J11: LED1; PAコネクタ(3ピンサイド型)
J12: BATT; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
R1: 430; R_0603_1608Metric
R2: 243; R_0603_1608Metric
R8: 100; R_0603_1608Metric
R9: 600; R_0603_1608Metric
R10: 300; R_0603_1608Metric
R11: 120; R_0603_1608Metric
R12, R13, R14, R15, R16, R17, R18, R19: 80; R_0603_1608Metric
R21: 420; R_0603_1608Metric
SW2: SW_Coded; RDS-1055-SMT
SW3: CAN_R; SLW
U1: TLV1117-33; SOT-223-3_TabPin2
U7: LED_GRB; LED_ROHM_SMLVN6
U8: TLV760; SOT-23

Connections:
+3.3V: C2.1, U1.2 (VO); also elsewhere on the board
+5V: C1.1, D1.2 (A), D6.1 (K), D17.2 (A), U1.3 (VI); also elsewhere on the board
+5VA: C13.1, D15.2 (A), D16.2 (A), JP2.1 (A), U8.1 (OUT); also elsewhere on the board
+BATT: J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.2, JP2.2 (C)
/CAN/CAN_H: J3.3, R11.1; also elsewhere on the board
/CAN/CAN_L: J3.4, SW3.3 (C); also elsewhere on the board
/Isolator/LED1: D7.2 (A); also elsewhere on the board
/Isolator/LED1A: J4.2; also elsewhere on the board
/Isolator/LED2: D8.2 (A); also elsewhere on the board
/Isolator/LED2A: J5.2; also elsewhere on the board
/Isolator/LED3: D9.2 (A); also elsewhere on the board
/Isolator/LED3A: J6.2; also elsewhere on the board
/Isolator/LED4: D10.2 (A); also elsewhere on the board
/Isolator/LED4A: J7.2; also elsewhere on the board
/Isolator/LED5: D11.2 (A); also elsewhere on the board
/Isolator/LED5A: J8.2; also elsewhere on the board
/Isolator/LED6: D12.2 (A); also elsewhere on the board
/Isolator/LED6A: J9.2; also elsewhere on the board
/Isolator/LED7: D13.2 (A); also elsewhere on the board
/Isolator/LED7A: J10.2; also elsewhere on the board
/Isolator/LED8: D14.2 (A); also elsewhere on the board
/Isolator/LED8A: J11.2; also elsewhere on the board
/MCU/ID0: SW2.2 (D0); also elsewhere on the board
/MCU/ID1: SW2.3 (D1); also elsewhere on the board
/MCU/ID2: SW2.4 (D2); also elsewhere on the board
/MCU/ID3: SW2.5 (D3); also elsewhere on the board
/MCU/LED_B: R8.2; also elsewhere on the board
/MCU/LED_G: R10.2; also elsewhere on the board
/MCU/LED_R: R9.2; also elsewhere on the board
GNDA: C13.2, C14.2, H2.1, H4.1, J4.3, J5.3, J6.3, J7.3, J8.3, J9.3, J10.3, J11.3, J12.1, R2.2, U8.3 (GND); also elsewhere on the board
GNDD: C1.2, C2.2, H1.1, H3.1, J3.5, J3.6, R1.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, SW2.1 (CM), SW3.6 (C), U1.1 (GND), U7.4, U7.5, U7.6; also elsewhere on the board
unnamed: D1.1 (K), R1.1
unnamed: D6.2 (A), F2.1
unnamed: D7.1 (K), R12.1
unnamed: D8.1 (K), R13.1
unnamed: D9.1 (K), R14.1
unnamed: D10.1 (K), R15.1
unnamed: D11.1 (K), R16.1
unnamed: D12.1 (K), R17.1
unnamed: D13.1 (K), R18.1
unnamed: D14.1 (K), R19.1
unnamed: D15.1 (K), R2.1
unnamed: C14.1, D16.1 (K), JP2.3 (B), U8.2 (IN)
unnamed: D17.1 (K), R21.1
unnamed: F2.2, J3.1, J3.2
unnamed: R8.1, U7.1
unnamed: R9.1, U7.2
unnamed: R10.1, U7.3
unnamed: R11.2, SW3.2 (B)
unnamed: R21.2, SW3.5 (B)

Notes on the sheet:
Vcc = 5.0V Vf = 2.2V, If = 11.5mA (5.0 - 2.2) / 0.0115 = 243Ω
終端抵抗の接続切り替え
Vcc = 3.3V Vf = 2.9V, If = 5mA (3.3 - 2.9) / 0.005 = 80Ω
Vcc = 5V Vf = 2.9V, If = 5mA (5 - 2.9) / 0.005 = 420Ω
Vcc = 5.0V Vf = 2.2V, If = 6.5mA (5.0 - 2.2) / 0.0065 = 430Ω

Parts:
C15, C16, C17, C18: 0.1u; C_0603_1608Metric
U4, U5: ISO6740; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
+3.3V: C15.2, C17.2, U4.1 (V_{CC1}), U5.1 (V_{CC1}); also elsewhere on the board
+5VA: C16.1, C18.1, U4.10 (EN2), U4.16 (V_{CC2}), U5.10 (EN2), U5.16 (V_{CC2}); also elsewhere on the board
/Isolator/LED1: U4.3 (INA); also elsewhere on the board
/Isolator/LED1A: U4.14 (OUTA); also elsewhere on the board
/Isolator/LED2: U4.4 (INB); also elsewhere on the board
/Isolator/LED2A: U4.13 (OUTB); also elsewhere on the board
/Isolator/LED3: U4.5 (INC); also elsewhere on the board
/Isolator/LED3A: U4.12 (OUTC); also elsewhere on the board
/Isolator/LED4: U4.6 (IND); also elsewhere on the board
/Isolator/LED4A: U4.11 (OUTD); also elsewhere on the board
/Isolator/LED5: U5.3 (INA); also elsewhere on the board
/Isolator/LED5A: U5.14 (OUTA); also elsewhere on the board
/Isolator/LED6: U5.4 (INB); also elsewhere on the board
/Isolator/LED6A: U5.13 (OUTB); also elsewhere on the board
/Isolator/LED7: U5.5 (INC); also elsewhere on the board
/Isolator/LED7A: U5.12 (OUTC); also elsewhere on the board
/Isolator/LED8: U5.6 (IND); also elsewhere on the board
/Isolator/LED8A: U5.11 (OUTD); also elsewhere on the board
GNDA: C16.2, C18.2, U4.9 (GND2), U4.15 (GND2), U5.9 (GND2), U5.15 (GND2); also elsewhere on the board
GNDD: C15.1, C17.1, U4.2 (GND1), U4.8 (GND1), U5.2 (GND1), U5.8 (GND1); also elsewhere on the board

Parts:
C11: 0.1u; C_0603_1608Metric
D2: CAN_TX; LED_0603_1608Metric
D3: CAN_RX; LED_0603_1608Metric
JP1: MCP2561/2FD selector; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R3, R4: 96; R_0603_1608Metric
U3: MCP2561/2FD; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C11.1, JP1.2 (B), U3.3 (VDD); also elsewhere on the board
/CAN/CAN_H: U3.7 (CANH); also elsewhere on the board
/CAN/CAN_L: U3.6 (CANL); also elsewhere on the board
/CAN/CAN_RX: D3.2 (A), U3.4 (RXD); also elsewhere on the board
/CAN/CAN_TX: D2.2 (A), U3.1 (TXD); also elsewhere on the board
GNDD: C11.2, R3.2, R4.2, U3.2 (VSS), U3.8 (STBY); also elsewhere on the board
unnamed: D2.1 (K), R3.1
unnamed: D3.1 (K), R4.1
unnamed: JP1.1 (A), U3.5 (VIO)

Notes on the sheet:
MCP2562FDを使うならジャンパする
Vcc = 3.3V Vf = 2.1V, If = 12.5mA (3.3 - 2.1) / 0.0125 = 96Ω

Parts:
C3, C4, C6, C10: 0.1u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C7: 1u; C_0603_1608Metric
C8, C9: 15p; C_0603_1608Metric
FB1: FerriteBead; L_0603_1608Metric
J1: SWD; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
R20: 10k; R_0603_1608Metric
R22: 10k; R_0603_1608Metric; not fitted
SW1: Reset; TVAF06-A020B-R
U2: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
Y1: 32MHz; XRCGB

Connections:
+3.3V: C3.1, C4.1, C5.1, FB1.1, R22.2, U2.1 (VDD), U2.17 (VDD); also elsewhere on the board
+3.3VADC: C6.1, C7.1, FB1.2, U2.5 (VDDA)
/CAN/CAN_RX: U2.21 (PA11); also elsewhere on the board
/CAN/CAN_TX: U2.22 (PA12); also elsewhere on the board
/Isolator/LED1: U2.7 (PA1); also elsewhere on the board
/Isolator/LED2: U2.8 (PA2); also elsewhere on the board
/Isolator/LED3: U2.9 (PA3); also elsewhere on the board
/Isolator/LED4: U2.11 (PA5); also elsewhere on the board
/Isolator/LED5: U2.12 (PA6); also elsewhere on the board
/Isolator/LED6: U2.13 (PA7); also elsewhere on the board
/Isolator/LED7: U2.14 (PB0); also elsewhere on the board
/Isolator/LED8: U2.15 (PB1); also elsewhere on the board
/MCU/ID0: U2.27 (PB4); also elsewhere on the board
/MCU/ID1: U2.29 (PB6); also elsewhere on the board
/MCU/ID2: U2.28 (PB5); also elsewhere on the board
/MCU/ID3: U2.30 (PB7); also elsewhere on the board
/MCU/LED_B: U2.18 (PA8); also elsewhere on the board
/MCU/LED_G: U2.20 (PA10); also elsewhere on the board
/MCU/LED_R: U2.19 (PA9); also elsewhere on the board
/MCU/NRST: C10.1, J1.4, SW1.2, U2.4 (NRST)
/MCU/SWCLK: J1.2, U2.24 (PA14)
/MCU/SWDIO: J1.1, U2.23 (PA13)
/MCU/UART2_RX: U2.25 (PA15); also elsewhere on the board
/MCU/UART2_TX: U2.26 (PB3); also elsewhere on the board
GNDD: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J1.3, R20.1, SW1.1, U2.16 (VSS), U2.32 (VSS); also elsewhere on the board
unnamed: R20.2, R22.1, U2.31 (BOOT0)
unnamed: C8.1, U2.2 (PF0), Y1.1
unnamed: C9.1, U2.3 (PF1), Y1.3

Notes on the sheet:
PWM1: PA1: TIM2_CH2 PWM2: PA2: TIM2_CH3 PWM3: PA3: TIM2_CH4 PWM4: PA5: TIM2_CH1 PWM5: PA6: TIM3_CH1 PWM6: PA7: TIM3_CH2 PWM7: PB0: TIM3_CH3 PWM8: PB1: TIM3_CH4 LED_R: TIM1_CH2 LED_G: TIM1_CH3 LED_B: TIM1_CH1 USART2_TX: PB3 USART2_RX: PA15

Parts:
C12: 0.1u; C_0603_1608Metric
D4: DATA; LED_0603_1608Metric
D5: D; Nexperia_CFP3_SOD-123W
F1: Polyfuse; MF-FSMF
J2: DEBUG; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R5, R6: 5.1k; R_0603_1608Metric
R7: 96; R_0603_1608Metric
U6: CH340E; MSOP-10_3x3mm_P0.5mm

Connections:
+3.3V: C12.1, U6.7 (VCC), U6.10 (V3); also elsewhere on the board
+5V: D5.1 (K); also elsewhere on the board
/MCU/UART2_RX: U6.8 (TXD); also elsewhere on the board
/MCU/UART2_TX: U6.9 (RXD); also elsewhere on the board
GNDD: C12.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), R5.2, R6.2, R7.2, U6.3 (GND); also elsewhere on the board
unnamed: D4.2 (A), U6.6 (TNOW)
unnamed: D4.1 (K), R7.1
unnamed: D5.2 (A), F1.1
unnamed: F1.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: J2.A5 (CC1), R6.1
unnamed: J2.B5 (CC2), R5.1
unnamed: J2.A6 (D+), J2.B6 (D+), U6.1 (UD+)
unnamed: J2.A7 (D-), J2.B7 (D-), U6.2 (UD-)

Notes on the sheet:
Vcc = 3.3V Vf = 2.1V, If = 12.5mA (3.3 - 2.1) / 0.0125 = 96Ω

Board: 4 copper layers, 70.0 x 45.0 mm, 90 parts (24 on the bottom side), 72 nets.

File PWMBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C5",0603,3,4.7u,
"C10, C11, C12, C13, C14, C15, C16, C17, C18, C3, C4, C6",0603,12,0.1u,
C7,0603,1,1u,
"C8, C9",0603,2,15p,
"D1, D10, D11, D12, D13, D14, D15, D17, D7, D8, D9",0603,11,LED,
"D16, D5, D6",Nexperia_CFP3_SOD-123W,3,D,
D2,0603,1,CAN_TX,
D3,0603,1,CAN_RX,
D4,0603,1,Data,
"F1, F2",MF-FSMF,2,Polyfuse,
FB1,0603,1,FerriteBead,
J1,JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal,1,SWD,
"J10, J11, J4, J5, J6, J7, J8, J9",PAコネクタ(3ピンサイド型),8,LED1,
J12,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,1,BATT,
J2,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,Debug,
J3,IDC-Header_2x03_P2.54mm_Horizontal,1,CAN,
R1,0603,1,430,
R10,0603,1,300,
R11,0603,1,120,
"R12, R13, R14, R15, R16, R17, R18, R19",0603,8,80,
R2,0603,1,243,
"R20, R22",0603,2,10k,
R21,0603,1,420,
"R3, R4, R7",0603,3,96,
"R5, R6",0603,2,5.1k,
R8,0603,1,100,
R9,0603,1,600,
SW1,TVAF06-A020B-R,1,Reset,
SW2,RDS-1055-SMT,1,SW_Coded,
SW3,SLW,1,CAN_R,
U1,SOT-223-3_TabPin2,1,TLV1117-33,
U2,LQFP-32_7x7mm_P0.8mm,1,STM32F303K8Tx,
U3,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2561/2FD,
"U4, U5",SOIC-16W_7.5x10.3mm_P1.27mm,2,ISO6740,
U6,MSOP-10_3x3mm_P0.5mm,1,CH340E,
U7,LED_ROHM_SMLVN6,1,LED_GRB,
U8,SOT-23,1,TLV760,
Y1,XRCGB,1,Crystal_GND2,

## KiCad design PowerBoard/PowerBoard.kicad_pcb

File PowerBoard/README.md:

# Power Board

電源の監視、制御電源の生成、非常停止などを行う電源基板

## 変更履歴

### ver1.0 (完成日：2025/05/31)
- 初回完成

Parts:
BZ1: Buzzer; MagneticBuzzer_CUI_CMT-8504-100-SMT
C1, C2: 4.7u; C_0603_1608Metric
C34, C36: 0.33u; C_0805_2012Metric
C35, C37: 0.1u; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
D2: D; Nexperia_CFP3_SOD-123W
D3: PWR; LED_0603_1608Metric
D4: BATT; LED_0603_1608Metric
D5: 24VA; LED_0603_1608Metric
D6: D; D_SOD-128
D17: D_TVS; D_SMC_Handsoldering
D18: D_TVS; D_SOD-323_HandSoldering
F2: Polyfuse; MF-USML_X
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H5: MountingHole; Title
H6: MountingHole; Info_M
H7: MountingHole; Aho_new_M
H8: MountingHole; Aho_old_M
J1: CAN; PAコネクタ(4ピントップ型)
J2: Vin; AMASS_XT60-M_1x02_P7.20mm_Vertical
J3, J12: Vout; AMASS_XT60-F_1x02_P7.20mm_Vertical
J4: Power; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal
JP1: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
R1: 420; R_0603_1608Metric
R2: 430; R_0603_1608Metric
R3, R5: 1.5k; R_0603_1608Metric
R4: 120; R_0603_1608Metric
R6: 100; R_0603_1608Metric
R7: 600; R_0603_1608Metric
R8: 300; R_0603_1608Metric
R9: 1k; R_0603_1608Metric
R10, R11: 5.1k; R_0603_1608Metric
SW1: CAN_R; SLW
U1: TLV1117-33; SOT-223-3_TabPin2
U2: LED_GRB; LED_ROHM_SMLVN6
U3: RECxxK-AW
U12: NJM7812SDL1; TO-252-2
U13: LM7805; TO-252-2

Connections:
+3.3VD: C2.1, U1.2 (VO); also elsewhere on the board
+5VA: C37.1, U13.3 (Vout); also elsewhere on the board
+5VD: C1.1, D1.2 (A), D2.2 (A), D3.2 (A), D6.1 (K), D18.2 (A2), U1.3 (VI); also elsewhere on the board
+12VA: C35.1, U12.3 (Vout); also elsewhere on the board
+24VA: D5.2 (A), D17.2 (A2), J3.2, J12.2; also elsewhere on the board
+BATT: D4.2 (A), J2.2; also elsewhere on the board
/5V_DCDC: JP1.3 (B), U3.6 (+Vout)
/5V_USB: J4.A9 (VBUS), J4.B9 (VBUS), JP1.1 (A)
/CAN/CAN_H: J1.2, R4.1; also elsewhere on the board
/CAN/CAN_L: J1.3, SW1.1 (A); also elsewhere on the board
/EMG/Vin_SENSED: U3.1 (+Vin); also elsewhere on the board
/MCU/BUZZER: R9.2; also elsewhere on the board
/MCU/LED_B: R6.2; also elsewhere on the board
/MCU/LED_G: R8.2; also elsewhere on the board
/MCU/LED_R: R7.2; also elsewhere on the board
/Vin_SENSED: C34.1, C36.1, U12.1 (Vin), U13.1 (Vin)
GNDA: C34.2, C35.2, C36.2, C37.2, D17.1 (A1), H3.1, H4.1, J2.1, J3.1, J12.1, R3.2, R5.2, U3.2 (-Vin), U12.2 (GND), U13.2 (GND); also elsewhere on the board
GNDD: BZ1.2 (-), C1.2, C2.2, D18.1 (A1), H1.1, H2.1, J1.4, J4.A12 (GND), J4.B12 (GND), R2.2, R10.2, R11.2, SW1.4 (A), U1.1 (GND), U2.4, U2.5, U2.6, U3.4 (-Vout); also elsewhere on the board
unnamed: BZ1.1 (+), R9.1
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), J1.1
unnamed: D3.1 (K), R2.1
unnamed: D4.1 (K), R3.1
unnamed: D5.1 (K), R5.1
unnamed: D6.2 (A), F2.1
unnamed: J4.A5 (CC1), R11.1
unnamed: J4.B5 (CC2), R10.1
unnamed: F2.2, JP1.2 (C)
unnamed: R6.1, U2.1
unnamed: R7.1, U2.2
unnamed: R8.1, U2.3
unnamed: R4.2, SW1.2 (B)
unnamed: R1.1, SW1.5 (B)

Notes on the sheet:
終端抵抗の接続切り替え

Parts:
C3, C7, C8, C9: 0.1u; C_0603_1608Metric
C4, C5: 15p; C_0603_1608Metric
C6: 4.7u; C_0603_1608Metric
C10: 1u; C_0603_1608Metric
FB1: FerriteBead; L_0603_1608Metric
J5: SWD; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
R12: 10k; R_0603_1608Metric
R36: 10k; R_0603_1608Metric; not fitted
SW2: Reset; TVAF06-A020B-R
U4: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
Y1: Crystal_GND2; XRCGB

Connections:
+3.3VADC: C9.1, C10.1, FB1.2, U4.5 (VDDA)
+3.3VD: C6.1, C7.1, C8.1, FB1.1, R36.2, U4.1 (VDD), U4.17 (VDD); also elsewhere on the board
/CAN/CAN_RX: U4.21 (PA11); also elsewhere on the board
/CAN/CAN_TX: U4.22 (PA12); also elsewhere on the board
/EMG/DISCHARGE: U4.19 (PA9); also elsewhere on the board
/EMG/EMG_EXSIG: U4.27 (PB4); also elsewhere on the board
/EMG/EMG_STATE: U4.11 (PA5); also elsewhere on the board
/EMG/IREF_SENSE: U4.14 (PB0); also elsewhere on the board
/EMG/I_SENSE: U4.13 (PA7); also elsewhere on the board
/EMG/SOFT_EMG: U4.18 (PA8); also elsewhere on the board
/EMG/V_SENSE: U4.12 (PA6); also elsewhere on the board
/MCU/BUZZER: U4.9 (PA3); also elsewhere on the board
/MCU/LED_B: U4.8 (PA2); also elsewhere on the board
/MCU/LED_G: U4.6 (PA0); also elsewhere on the board
/MCU/LED_R: U4.7 (PA1); also elsewhere on the board
/MCU/NRST: C3.1, J5.4, SW2.2, U4.4 (NRST)
/MCU/SWCLK: J5.2, U4.24 (PA14)
/MCU/SWDIO: J5.1, U4.23 (PA13)
/MCU/UART_RX: U4.25 (PA15); also elsewhere on the board
/MCU/UART_TX: U4.26 (PB3); also elsewhere on the board
GNDD: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J5.3, R12.1, SW2.1, U4.16 (VSS), U4.32 (VSS); also elsewhere on the board
unnamed: R12.2, R36.1, U4.31 (BOOT0)
unnamed: C4.1, U4.2 (PF0), Y1.1
unnamed: C5.1, U4.3 (PF1), Y1.3

Notes on the sheet:
V_SENSE: PA6: ADC2_IN3 I_SENSE: PA7: ADC2_IN4 IREF_SENSE: PB0: ADC1_IN11 LED_R: PA1: TIM2_CH2 LED_G: PA0: TIM2_CH1 LED_B: PA2: TIM2_CH3 BUZZER: PB0: TIM3_CH3 UART_TX: PB3: USART2_TX UART_RX: PA15: USART2_RX

Parts:
C12: 0.1u; C_0603_1608Metric
D10: D; Nexperia_CFP3_SOD-123W
D11: LED; LED_0603_1608Metric
F1: Polyfuse; MF-FSMF
J6: Debug; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R15, R16: 5.1k; R_0603_1608Metric
R17: 96; R_0603_1608Metric
U6: CH340E; MSOP-10_3x3mm_P0.5mm

Connections:
+3.3VD: C12.1, U6.7 (VCC), U6.10 (V3); also elsewhere on the board
+5VD: D10.1 (K); also elsewhere on the board
/MCU/UART_RX: U6.8 (TXD); also elsewhere on the board
/MCU/UART_TX: U6.9 (RXD); also elsewhere on the board
GNDD: C12.2, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), R15.2, R16.2, R17.2, U6.3 (GND); also elsewhere on the board
unnamed: D10.2 (A), F1.1
unnamed: D11.2 (A), U6.6 (TNOW)
unnamed: D11.1 (K), R17.1
unnamed: F1.2, J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS)
unnamed: J6.A5 (CC1), R16.1
unnamed: J6.B5 (CC2), R15.1
unnamed: J6.A6 (D+), J6.B6 (D+), U6.1 (UD+)
unnamed: J6.A7 (D-), J6.B7 (D-), U6.2 (UD-)

Parts:
C11: 0.1u; C_0603_1608Metric
D8, D9: LED; LED_0603_1608Metric
JP2: MCP2561/2FD selector; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R13, R14: 96; R_0603_1608Metric
U5: MCP2561/2FD; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5VD: C11.1, JP2.2 (B), U5.3 (VDD); also elsewhere on the board
/CAN/CAN_H: U5.7 (CANH); also elsewhere on the board
/CAN/CAN_L: U5.6 (CANL); also elsewhere on the board
/CAN/CAN_RX: D9.2 (A), U5.4 (RXD); also elsewhere on the board
/CAN/CAN_TX: D8.2 (A), U5.1 (TXD); also elsewhere on the board
GNDD: C11.2, R13.2, R14.2, U5.2 (VSS), U5.8 (STBY); also elsewhere on the board
unnamed: D8.1 (K), R13.1
unnamed: D9.1 (K), R14.1
unnamed: JP2.1 (A), U5.5 (VIO)

Notes on the sheet:
MCP2562FDを使うならジャンパする
