# Repository mgsin30/Robocon2025-PCB (continued)

## KiCad design MotorDriver/MotorDriver.kicad_pcb (continued)

Parts:
C24: 0.1u; C_0603_1608Metric
D15: D; Nexperia_CFP3_SOD-123W
D16: DATA; LED_0603_1608Metric
F2: Polyfuse; MF-FSMF
J8: Debug; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R33, R34: 5.1k; R_0603_1608Metric
R35: 100; R_0603_1608Metric
U10: CH340E; MSOP-10_3x3mm_P0.5mm

Connections:
+3.3VD: C24.1, U10.7 (VCC), U10.10 (V3); also elsewhere on the board
+5VD: F2.1; also elsewhere on the board
/MCU/UART2_RX: U10.8 (TXD); also elsewhere on the board
/MCU/UART2_TX: U10.9 (RXD); also elsewhere on the board
GNDD: C24.2, J8.A1 (GND), J8.A12 (GND), J8.B1 (GND), J8.B12 (GND), R33.2, R34.2, R35.2, U10.3 (GND); also elsewhere on the board
unnamed: D15.2 (A), J8.A4 (VBUS), J8.A9 (VBUS), J8.B4 (VBUS), J8.B9 (VBUS)
unnamed: D15.1 (K), F2.2
unnamed: D16.2 (A), U10.6 (TNOW)
unnamed: D16.1 (K), R35.1
unnamed: J8.A5 (CC1), R34.1
unnamed: J8.B5 (CC2), R33.1
unnamed: J8.A6 (D+), J8.B6 (D+), U10.1 (UD+)
unnamed: J8.A7 (D-), J8.B7 (D-), U10.2 (UD-)

Board: 4 copper layers, 70.0 x 45.0 mm, 125 parts (69 on the bottom side), 94 nets.

File MotorDriver/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,0.33u,
"C10, C13",0603,2,2.5u,
"C11, C12, C8",0603,3,1000p,
"C14, C15, C19, C20, C21, C23, C24, C25, C26, C3, C7, C9",0603,12,0.1u,
"C16, C17",0603,2,15p,
"C18, C2, C4",0603,3,4.7u,
C22,0603,1,1u,
"C5, C6",CP_Elec_10x10.5,2,330u,
"D1, D15",Nexperia_CFP3_SOD-123W,2,D,
D10,0603,1,OCD1,
D11,0603,1,OCD2,
"D12, D7",D_SOD-123,2,D_Schottky,
D13,0603,1,CAN_TX,
D14,0603,1,CAN_RX,
D16,0603,1,DATA,
D2,0603,1,CAN_R,
D3,0603,1,SW2,
D4,0603,1,SW1,
D5,0603,1,PWR,
D6,0603,1,BATT,
D8,0603,1,MA,
D9,0603,1,MB,
"F1, F2",MF-FSMF,2,Polyfuse,
FB1,0603,1,FerriteBead,
J1,IDC-Header_2x03_P2.54mm_Horizontal,1,CAN,
J2,SM05B-PASS-TBx,1,ENC,
J3,SM02B-PASS-TBx,1,SW1,
J4,SM02B-PASS-TBx,1,SW2,
J5,XT60PW-M_Horizontal,1,VIN,
J6,XT60PW-F_Horizontal,1,Motor,
J7,JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal,1,SWD,
J8,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,Debug,
"Q1, Q2",Vishay_PowerPAK_8x8L_Dual,2,Q_NMOS,
Q3,TSOT-23,1,Q_NMOS_GSD,
"R1, R22, R23",0603,3,420,
R10,0603,1,430,
"R11, R18",0603,2,1.5k,
R12,0603,1,13k,
R13,0603,1,2.4k,
R14,0603,1,18k,
R15,0603,1,3k,
"R16, R17, R26, R27, R8, R9",0603,6,80,
"R19, R20, R24, R25, R29, R30, R39, R40",0603,8,10k,
R2,0603,1,120,
R21,0603,1,3.7k,
R28,0603,1,1k,
"R3, R31, R32, R35",0603,4,100,
"R33, R34",0603,2,5.1k,
"R36, R37",0603,2,350,
R38,0603,1,660,
R4,0603,1,600,
R5,0603,1,300,
"R6, R7",0603,2,330,
"RV1, RV2",ST-4ETB103,2,10k,
SW1,SLW,1,CAN_R,
SW2,RDS-1055-SMT,1,SW_Coded,
SW3,TVAF06-A020B-R,1,RESET,
U1,LED_ROHM_SMLVN6,1,LED_GRB,
U10,MSOP-10_3x3mm_P0.5mm,1,CH340E,
"U11, U12",SO-5-6_4.55x3.7mm_P1.27mm,2,TLP2348,
U2,TO-252-2,1,NJM7812SDL1,
U3,SOT-223-3_TabPin2,1,TLV1117-33,
U4,CZ3A,1,CZ-3A05,
"U5, U6",SOIC-8_3.9x4.9mm_P1.27mm,2,IR2302,
U7,SOIC-4_4.55x2.6mm_P1.27mm,1,TLP293,
U8,LQFP-32_7x7mm_P0.8mm,1,STM32F303K8Tx,
U9,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2561/2FD,
Y1,XRCGB,1,Crystal_GND2,

## KiCad design GPIOBoard/GPIOBoard.kicad_pcb

File GPIOBoard/README.md:

# GPIO Board

リミットスイッチや IMU を接続したり、GPIO を利用したりするための基板

## 変更履歴

### ver1.0 (発注日：2025/03/10)
- 初回完成

### ver1.1 (発注日：2025/04/12)
- 三端子レギュレーターの型番を変更
- ショットキーバリアダイオードの型番を変更
- 各LEDの型番を変更
- 電源確認用LEDの場所を変更
- RGBLEDを追加
- 終端抵抗接続用スイッチの型番を変更
- 終端抵抗接続確認用のLEDを追加
- シルクを微調整
- 水晶発振子のフットプリントを修正

### ver1.2 (発注日：2025/07/01)
- USB-Cコネクタの位置を微調整
- 基板下部の取付穴を通常の穴に変更

### ver1.3 (発注日：2025/07/16)
- USBのCCピンが未配線だったのを修正
- フットプリントを更新

Parts:
C1, C2: 4.7u; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_0603_1608Metric
D9: TX; LED_0603_1608Metric
D10: RX; LED_0603_1608Metric
D11: PWR; LED_0603_1608Metric
D16: D; Nexperia_CFP3_SOD-123W
D17: CAN_R; LED_0603_1608Metric
F1: Polyfuse; MF-FSMF
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: GPIO1; PAコネクタ(3ピンサイド型)
J2: GPIO2; PAコネクタ(3ピンサイド型)
J3: GPIO3; PAコネクタ(3ピンサイド型)
J4: GPIO4; PAコネクタ(3ピンサイド型)
J5: GPIO5; PAコネクタ(3ピンサイド型)
J6: GPIO6; PAコネクタ(3ピンサイド型)
J7: GPIO7; PAコネクタ(3ピンサイド型)
J8: GPIO8; PAコネクタ(3ピンサイド型)
J9: IMU; PAコネクタ(4ピンサイド型)
J12: CAN; IDC-Header_2x03_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8: 80; R_0603_1608Metric
R9, R10, R11, R12, R13, R14, R15, R16: 330; R_0603_1608Metric
R17, R18: 96; R_0603_1608Metric
R19: 430; R_0603_1608Metric
R25: 120; R_0603_1608Metric
R27: 420; R_0603_1608Metric
R28: 100; R_0603_1608Metric
R29: 600; R_0603_1608Metric
R30: 300; R_0603_1608Metric
SW2: SW_Coded; RDS-1055-SMT
SW3: CAN_R; SLW
U2: TLV1117-33; SOT-223-3_TabPin2
U5: LED_GRB; LED_ROHM_SMLVN6

Connections:
+3.3V: C2.1, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, U2.2 (VO); also elsewhere on the board
+5V: C1.1, D11.2 (A), D16.1 (K), D17.2 (A), J9.1, U2.3 (VI); also elsewhere on the board
/CAN/CAN_H: J12.3, R25.1; also elsewhere on the board
/CAN/CAN_L: J12.4, SW3.1 (A); also elsewhere on the board
/MCU/GPIO1: R9.2; also elsewhere on the board
/MCU/GPIO2: R10.2; also elsewhere on the board
/MCU/GPIO3: R11.2; also elsewhere on the board
/MCU/GPIO4: R12.2; also elsewhere on the board
/MCU/GPIO5: R13.2; also elsewhere on the board
/MCU/GPIO6: R14.2; also elsewhere on the board
/MCU/GPIO7: R15.2; also elsewhere on the board
/MCU/GPIO8: R16.2; also elsewhere on the board
/MCU/ID0: SW2.2 (D0); also elsewhere on the board
/MCU/ID1: SW2.3 (D1); also elsewhere on the board
/MCU/ID2: SW2.4 (D2); also elsewhere on the board
/MCU/ID3: SW2.5 (D3); also elsewhere on the board
/MCU/LED_B: R28.2; also elsewhere on the board
/MCU/LED_G: R30.2; also elsewhere on the board
/MCU/LED_R: R29.2; also elsewhere on the board
/MCU/UART1_RX: D10.2 (A), J9.3; also elsewhere on the board
/MCU/UART1_TX: D9.2 (A), J9.2; also elsewhere on the board
GNDD: C1.2, C2.2, H1.1, H2.1, H3.1, H4.1, J1.3, J2.3, J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, J9.4, J12.5, J12.6, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R17.2, R18.2, R19.2, SW2.1 (CM), SW3.4 (A), U2.1 (GND), U5.4, U5.5, U5.6; also elsewhere on the board
unnamed: D1.2 (A), J1.2, R9.1
unnamed: D1.1 (K), R1.1
unnamed: D2.2 (A), J2.2, R10.1
unnamed: D2.1 (K), R2.1
unnamed: D3.2 (A), J3.2, R11.1
unnamed: D3.1 (K), R3.1
unnamed: D4.2 (A), J4.2, R12.1
unnamed: D4.1 (K), R4.1
unnamed: D5.2 (A), J5.2, R13.1
unnamed: D5.1 (K), R5.1
unnamed: D6.2 (A), J6.2, R14.1
unnamed: D6.1 (K), R6.1
unnamed: D7.2 (A), J7.2, R15.1
unnamed: D7.1 (K), R7.1
unnamed: D8.2 (A), J8.2, R16.1
unnamed: D8.1 (K), R8.1
unnamed: D9.1 (K), R17.1
unnamed: D10.1 (K), R18.1
unnamed: D11.1 (K), R19.1
unnamed: D16.2 (A), F1.1
unnamed: D17.1 (K), R27.1
unnamed: F1.2, J12.1, J12.2
unnamed: R28.1, U5.1
unnamed: R29.1, U5.2
unnamed: R30.1, U5.3
unnamed: R25.2, SW3.2 (B)
unnamed: R27.2, SW3.5 (B)

Notes on the sheet:
Vcc = 3.3V Vf = 2.1V, If = 12.5mA (3.3-2.1) / 0.0125 = 96Ω
Vcc = 5.0V Vf = 2.2V, If = 6.5mA (5.0-2.2) / 0.0065 = 430Ω
終端抵抗の接続切り替え
Vcc = 3.3V Vf = 2.9V, If = 5mA (3.3-2.9) / 0.005 = 80Ω
LEDの色 電源：オレンジ 通信：緑 その他：青
Vcc = 5V Vf = 2.9V, If = 5mA (5 - 2.9) / 0.005 = 420Ω

Parts:
C11: 0.1u; C_0603_1608Metric
D12: Data; LED_0603_1608Metric
D15: D; Nexperia_CFP3_SOD-123W
F2: Polyfuse; MF-FSMF
J10: Debug; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R20: 96; R_0603_1608Metric
R21, R22: 5.1k; R_0603_1608Metric
U3: CH340E; MSOP-10_3x3mm_P0.5mm

Connections:
+3.3V: C11.1, U3.7 (VCC), U3.10 (V3); also elsewhere on the board
+5V: D15.1 (K); also elsewhere on the board
/MCU/UART2_RX: U3.8 (TXD); also elsewhere on the board
/MCU/UART2_TX: U3.9 (RXD); also elsewhere on the board
GNDD: C11.2, J10.A1 (GND), J10.A12 (GND), J10.B1 (GND), J10.B12 (GND), R20.2, R21.2, R22.2, U3.3 (GND); also elsewhere on the board
unnamed: D12.2 (A), U3.6 (TNOW)
unnamed: D12.1 (K), R20.1
unnamed: D15.2 (A), F2.1
unnamed: F2.2, J10.A4 (VBUS), J10.A9 (VBUS), J10.B4 (VBUS), J10.B9 (VBUS)
unnamed: J10.A5 (CC1), R22.1
unnamed: J10.B5 (CC2), R21.1
unnamed: J10.A6 (D+), J10.B6 (D+), U3.1 (UD+)
unnamed: J10.A7 (D-), J10.B7 (D-), U3.2 (UD-)

Notes on the sheet:
Vcc = 3.3V Vf = 2.1V, If = 12.5mA (3.3-2.1) / 0.0125 = 96Ω

Parts:
C3, C4, C6, C8: 0.1u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C7: 1u; C_0603_1608Metric
C9, C10: 15p; C_0603_1608Metric
FB1: FerriteBead; L_0603_1608Metric
J11: SWD; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
R26: 10k; R_0603_1608Metric
R31: 10k; R_0603_1608Metric; not fitted
SW1: RESET; TVAF06-A020B-R
U1: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
Y1: Crystal_GND2; XRCGB

Connections:
+3.3V: C3.1, C4.1, C5.1, FB1.1, R31.1, U1.1 (VDD), U1.17 (VDD); also elsewhere on the board
+3.3VA: C6.1, C7.1, FB1.2, U1.5 (VDDA)
/CAN/CAN_RX: U1.21 (PA11); also elsewhere on the board
/CAN/CAN_TX: U1.22 (PA12); also elsewhere on the board
/MCU/GPIO1: U1.15 (PB1); also elsewhere on the board
/MCU/GPIO2: U1.14 (PB0); also elsewhere on the board
/MCU/GPIO3: U1.13 (PA7); also elsewhere on the board
/MCU/GPIO4: U1.12 (PA6); also elsewhere on the board
/MCU/GPIO5: U1.11 (PA5); also elsewhere on the board
/MCU/GPIO6: U1.9 (PA3); also elsewhere on the board
/MCU/GPIO7: U1.8 (PA2); also elsewhere on the board
/MCU/GPIO8: U1.7 (PA1); also elsewhere on the board
/MCU/ID0: U1.27 (PB4); also elsewhere on the board
/MCU/ID1: U1.29 (PB6); also elsewhere on the board
/MCU/ID2: U1.28 (PB5); also elsewhere on the board
/MCU/ID3: U1.30 (PB7); also elsewhere on the board
/MCU/LED_B: U1.6 (PA0); also elsewhere on the board
/MCU/LED_G: U1.18 (PA8); also elsewhere on the board
/MCU/LED_R: U1.10 (PA4); also elsewhere on the board
/MCU/NRST: C8.1, J11.4, SW1.2, U1.4 (NRST)
/MCU/SWCLK: J11.2, U1.24 (PA14)
/MCU/SWDIO: J11.1, U1.23 (PA13)
/MCU/UART1_RX: U1.20 (PA10); also elsewhere on the board
/MCU/UART1_TX: U1.19 (PA9); also elsewhere on the board
/MCU/UART2_RX: U1.25 (PA15); also elsewhere on the board
/MCU/UART2_TX: U1.26 (PB3); also elsewhere on the board
GNDD: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J11.3, R26.2, SW1.1, U1.16 (VSS), U1.32 (VSS); also elsewhere on the board
unnamed: R26.1, R31.2, U1.31 (BOOT0)
unnamed: C9.1, U1.2 (PF0), Y1.1
unnamed: C10.1, U1.3 (PF1), Y1.3

Notes on the sheet:
GPIO1: PB1: TIM3_CH4 GPIO2: PB0: TIM3_CH3 GPIO3: PA7: TIM3_CH2 GPIO4: PA6: TIM3_CH1 GPIO5: PA5: TIM2_CH1 GPIO6: PA3: TIM2_CH4 GPIO7: PA2: TIM2_CH3 GPIO8: PA1: TIM2_CH2 PA9: USART1_TX PA10: USART1_RX PB3: USART2_TX PA15: USART2_RX

Parts:
C12: 0.1u; C_0603_1608Metric
D13: CAN_TX; LED_0603_1608Metric
D14: CAN_RX; LED_0603_1608Metric
JP1: MCP2561/2FD selector; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R23, R24: 96; R_0603_1608Metric
U4: MCP2561/2FD; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C12.1, JP1.1 (A), U4.3 (VDD); also elsewhere on the board
/CAN/CAN_H: U4.7 (CANH); also elsewhere on the board
/CAN/CAN_L: U4.6 (CANL); also elsewhere on the board
/CAN/CAN_RX: D14.2 (A), U4.4 (RXD); also elsewhere on the board
/CAN/CAN_TX: D13.2 (A), U4.1 (TXD); also elsewhere on the board
GNDD: C12.2, R23.2, R24.2, U4.2 (VSS), U4.8 (STBY); also elsewhere on the board
unnamed: D13.1 (K), R23.1
unnamed: D14.1 (K), R24.1
unnamed: JP1.2 (B), U4.5 (VIO)

Notes on the sheet:
MCP2562FDを使うならジャンパする
Vcc = 3.3V Vf = 2.1V, If = 12.5mA (3.3-2.1) / 0.0125 = 96Ω

Board: 2 copper layers, 70.0 x 45.0 mm, 89 parts (11 on the bottom side), 71 nets.

File GPIOBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C5",0603,3,4.7u,
"C10, C9",0603,2,15p,
"C11, C12, C3, C4, C6, C8",0603,6,0.1u,
C7,0603,1,1u,
"D1, D2, D3, D4, D5, D6, D7, D8",0603,8,LED,
D10,0603,1,RX,
D11,0603,1,PWR,
D12,0603,1,Data,
D13,0603,1,CAN_TX,
D14,0603,1,CAN_RX,
"D15, D16",Nexperia_CFP3_SOD-123W,2,D,
D17,0603,1,CAN_R,
D9,0603,1,TX,
"F1, F2",MF-FSMF,2,Polyfuse,
FB1,0603,1,FerriteBead,
J1,PAコネクタ(3ピンサイド型),1,GPIO1,
J10,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,Debug,
J11,JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal,1,SWD,
J12,IDC-Header_2x03_P2.54mm_Horizontal,1,CAN,
J2,PAコネクタ(3ピンサイド型),1,GPIO2,
J3,PAコネクタ(3ピンサイド型),1,GPIO3,
J4,PAコネクタ(3ピンサイド型),1,GPIO4,
J5,PAコネクタ(3ピンサイド型),1,GPIO5,
J6,PAコネクタ(3ピンサイド型),1,GPIO6,
J7,PAコネクタ(3ピンサイド型),1,GPIO7,
J8,PAコネクタ(3ピンサイド型),1,GPIO8,
J9,PAコネクタ(4ピンサイド型),1,IMU,
"R1, R2, R3, R4, R5, R6, R7, R8",0603,8,80,
"R10, R11, R12, R13, R14, R15, R16, R9",0603,8,330,
"R17, R18, R20, R23, R24",0603,5,96,
R19,0603,1,430,
"R21, R22",0603,2,5.1k,
R25,0603,1,120,
"R26, R31",0603,2,10k,
R27,0603,1,420,
R28,0603,1,100,
R29,0603,1,600,
R30,0603,1,300,
SW1,TVAF06-A020B-R,1,RESET,
SW2,RDS-1055-SMT,1,SW_Coded,
SW3,SLW,1,CAN_R,
U1,LQFP-32_7x7mm_P0.8mm,1,STM32F303K8Tx,
U2,SOT-223-3_TabPin2,1,TLV1117-33,
U3,MSOP-10_3x3mm_P0.5mm,1,CH340E,
U4,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2561/2FD,
U5,LED_ROHM_SMLVN6,1,LED_GRB,
Y1,XRCGB,1,Crystal_GND2,

## KiCad design CANBusHub/CANBusHub.kicad_pcb

File CANBusHub/README.md:

# CAN Bus Hub

各基板と CANバス を接続する基板

## 変更履歴

### ver1.0 (完成日：2025/05/30)
- 初回完成

### ver1.1 (完成日：2025/07/13)
- 基板接続用コネクタとCANバス切替用スイッチの位置を変更
- CAN用コネクタの位置を変更
- 裏面にシルクスクリーンを追加

Parts:
D1: PWR; LED_0603_1608Metric
H1, H2, H3, H4, H5: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H6: MountingHole; Title
H7: MountingHole; Info_M
J1: CAN1_IN; PAコネクタ(4ピンサイド型)
J2: CAN2_IN; PAコネクタ(4ピンサイド型)
J3: CAN_OUT1; IDC-Header_2x03_P2.54mm_Vertical
J4: CAN_OUT2; IDC-Header_2x03_P2.54mm_Vertical
J5: CAN_OUT3; IDC-Header_2x03_P2.54mm_Vertical
J6: CAN_OUT4; IDC-Header_2x03_P2.54mm_Vertical
J7: CAN1_OUT; PAコネクタ(4ピンサイド型)
J8: CAN2_OUT; PAコネクタ(4ピンサイド型)
J11: PWR_IN; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal
R1: 430; R_0603_1608Metric
R2, R3: 5.1k; R_0603_1608Metric
SW1, SW2, SW3, SW4: CAN1/2; SLW
SW5, SW6, SW7, SW8: SW_DPDT_x2; SLW

Connections:
+5VD: D1.2 (A), J1.1, J2.1, J3.5, J3.6, J4.5, J4.6, J5.5, J5.6, J6.5, J6.6, J7.1, J8.1, J11.A9 (VBUS), J11.B9 (VBUS)
/CAN1_H: J1.2, J7.2, SW1.3 (C), SW2.3 (C), SW3.3 (C), SW4.3 (C), SW5.1 (A), SW6.1 (A), SW7.1 (A), SW8.1 (A)
/CAN1_L: J1.3, J7.3, SW1.6 (C), SW2.6 (C), SW3.6 (C), SW4.6 (C), SW5.4 (A), SW6.4 (A), SW7.4 (A), SW8.4 (A)
/CAN2_H: J2.2, J8.2, SW1.1 (A), SW2.1 (A), SW3.1 (A), SW4.1 (A), SW5.3 (C), SW6.3 (C), SW7.3 (C), SW8.3 (C)
/CAN2_L: J2.3, J8.3, SW1.4 (A), SW2.4 (A), SW3.4 (A), SW4.4 (A), SW5.6 (C), SW6.6 (C), SW7.6 (C), SW8.6 (C)
GNDD: H1.1, H2.1, H3.1, H4.1, H5.1, J1.4, J2.4, J3.1, J3.2, J4.1, J4.2, J5.1, J5.2, J6.1, J6.2, J7.4, J8.4, J11.A12 (GND), J11.B12 (GND), R1.2, R2.2, R3.2
unnamed: D1.1 (K), R1.1
unnamed: J3.3, SW1.2 (B), SW5.2 (B)
unnamed: J3.4, SW1.5 (B), SW5.5 (B)
unnamed: J4.3, SW2.2 (B), SW6.2 (B)
unnamed: J4.4, SW2.5 (B), SW6.5 (B)
unnamed: J5.3, SW3.2 (B), SW7.2 (B)
unnamed: J5.4, SW3.5 (B), SW7.5 (B)
unnamed: J6.3, SW4.2 (B), SW8.2 (B)
unnamed: J6.4, SW4.5 (B), SW8.5 (B)
unnamed: J11.A5 (CC1), R3.1
unnamed: J11.B5 (CC2), R2.1

Board: 2 copper layers, 100.0 x 57.0 mm, 28 parts (10 on the bottom side), 17 nets.

File CANBusHub/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
D1,0603,1,PWR,
J1,PAコネクタ(4ピンサイド型),1,CAN1_IN,
J11,USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal,1,PWR_IN,
J2,PAコネクタ(4ピンサイド型),1,CAN2_IN,
J3,IDC-Header_2x03_P2.54mm_Vertical,1,CAN_OUT1,
J4,IDC-Header_2x03_P2.54mm_Vertical,1,CAN_OUT2,
J5,IDC-Header_2x03_P2.54mm_Vertical,1,CAN_OUT3,
J6,IDC-Header_2x03_P2.54mm_Vertical,1,CAN_OUT4,
J7,PAコネクタ(4ピンサイド型),1,CAN1_OUT,
J8,PAコネクタ(4ピンサイド型),1,CAN2_OUT,
R1,0603,1,430,
"R2, R3",0603,2,5.1k,
"SW1, SW2, SW3, SW4",SLW,4,CAN1/2,
"SW5, SW6, SW7, SW8",SLW,4,SW_DPDT_x2,
