# Repository mgsin30/Robocon2025-PCB

File README.md:

# Robocon2025-PCB
高専ロボコン2025のために開発した基板 <br>
各基板のファームウェアは [こちら](https://github.com/mgsin30/Robocon2025-Firmware)

## CAN Bus Hub
各基板を CAN バスで接続するためのハブ基板

## Converter Board
サーボモーターや LED テープなどのために電源電圧を降圧する基板

## GPIO Board
リミットスイッチやジャイロセンサー、その他 GPIO を使うための基板

## Motor Driver
ブラシ付きモーター用のモータードライバー

## Power Board
電源電圧の監視や非常停止の管理などを行う電源基板

## PWM Board
サーボモーターなどを使うための基板

## Remote Emergency Stop Board (TX)
遠隔非常停止の送信側基板

## Remote Emergency Stop Board (RX)
遠隔非常停止の受信側基板

## RoboMaster Board
ロボマスモーターを使うための基板

## Solenoid Driver
ソレノイドや電磁弁などを使うための基板

## USB-CAN Board
USB と CAN を変換する基板

## XT30 Hub
XT30 コネクタのハブ基板

## XT60 Hub
XT60 コネクタのハブ基板

## KiCad design LEDBoard/LEDBoard.kicad_pcb

File LEDBoard/README.md:

# LED Board

LEDテープ WS2812B を光らせるための基板

## 変更履歴

### ver1.0 (完成日：2025/09/25)
- 初回完成

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1: 0.1u; C_0603_1608Metric
D1: LED; LED_D5.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H5: MountingHole; Title
H6: MountingHole; Info_L
H7: MountingHole; Aho_old_S
H8: MountingHole; Aho_new_S
J1: PWR; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J2: LED1; PAコネクタ(3ピントップ型)
J3: LED2; PAコネクタ(3ピントップ型)
J4: LED3; PAコネクタ(3ピントップ型)
J5: LED4; PAコネクタ(3ピントップ型)
J6: IN1; PAコネクタ(3ピントップ型)
J7: IN2; PAコネクタ(3ピントップ型)
R1, R2: R; R_0603_1608Metric
R5, R6: 10k; R_0603_1608Metric
RV1: Red; TSR-3386K
RV2: Green; TSR-3386K
RV3: Blue; TSR-3386K
RV4: Brightness; TSR-3386K
SW1: MODE; SS-12D00G3
U1, U2: TLP291; SOIC-4_4.55x2.6mm_P1.27mm

Connections:
+5VA: A1.27 (+5V), C1.1, D1.2 (A), J1.2, J2.1, J3.1, J4.1, J5.1, RV1.1, RV2.1, RV3.1, RV4.1, SW1.1 (A), U1.4, U2.4
Blue: A1.21 (A2), RV3.2
Brightness: A1.22 (A3), RV4.2
GNDA: A1.4 (GND), A1.29 (GND), C1.2, D1.1 (K), H1.1, H2.1, H3.1, J1.1, J2.3, J3.3, J4.3, J5.3, R5.2, R6.2, RV1.3, RV2.3, RV3.3, RV4.3, SW1.3 (C)
GNDD: H4.1, J6.3, J7.3, U1.2, U2.2
Green: A1.20 (A1), RV2.2
IN1: A1.6 (D3), R5.1, U1.3
IN2: A1.7 (D4), R6.1, U2.3
LED1: A1.9 (D6), J2.2
LED2: A1.10 (D7), J3.2
LED3: A1.11 (D8), J4.2
LED4: A1.12 (D9), J5.2
MODE: A1.5 (D2), SW1.2 (B)
unnamed: J6.2, R1.1
unnamed: J7.2, R2.1
unnamed: R1.2, U1.1
unnamed: R2.2, U2.1
Red: A1.19 (A0), RV1.2

Notes on the sheet:
抵抗内蔵LED

Board: 2 copper layers, 70.0 x 40.0 mm, 29 parts (3 on the bottom side), 18 nets.

File LEDBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
A1,Arduino_Nano,1,Arduino_Nano_v3.x,
C1,0603,1,0.1u,
D1,LED_D5.0mm,1,LED,
J1,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,PWR,
J2,PAコネクタ(3ピントップ型),1,LED1,
J3,PAコネクタ(3ピントップ型),1,LED2,
J4,PAコネクタ(3ピントップ型),1,LED3,
J5,PAコネクタ(3ピントップ型),1,LED4,
J6,PAコネクタ(3ピントップ型),1,IN1,
J7,PAコネクタ(3ピントップ型),1,IN2,
"R1, R2",0603,2,R,
"R5, R6",0603,2,10k,
RV1,TSR-3386K,1,Red,
RV2,TSR-3386K,1,Green,
RV3,TSR-3386K,1,Blue,
RV4,TSR-3386K,1,Brightness,
SW1,SS-12D00G3,1,MODE,
"U1, U2",SOIC-4_4.55x2.6mm_P1.27mm,2,TLP291,

## KiCad design XT60Hub/XT60Hub.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: IN; AMASS_XT60-M_1x02_P7.20mm_Vertical
J2: OUT1; AMASS_XT60-F_1x02_P7.20mm_Vertical
J3: OUT2; AMASS_XT60-F_1x02_P7.20mm_Vertical
J4: OUT3; AMASS_XT60-F_1x02_P7.20mm_Vertical
J5: OUT4; AMASS_XT60-F_1x02_P7.20mm_Vertical
J6: OUT5; AMASS_XT60-F_1x02_P7.20mm_Vertical

Connections:
+BATT: H4.1, H5.1, H6.1, J1.2, J2.2, J3.2, J4.2, J5.2, J6.2
GND: H1.1, H2.1, H3.1, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1

Board: 2 copper layers, 12 parts (0 on the bottom side), 2 nets, no tracks yet.

File FanBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
J1,PAコネクタ(4ピンサイド型),1,Vin / CAN IN,
J2,PAコネクタ(2ピンサイド型),1,Vin,
J3,PAコネクタ(4ピンサイド型),1,CAN OUT,
J4,PAコネクタ(2ピンサイド型),1,OUT1,
J5,PAコネクタ(2ピンサイド型),1,OUT2,
J6,PAコネクタ(2ピンサイド型),1,OUT3,
SW1,SS-12D00G3,1,PWR,

## KiCad design ConverterBoard/ConverterBoard.kicad_pcb

File ConverterBoard/README.md:

# Converter Board

電源電圧を各電圧に降圧するための基板

## 変更履歴

### ver1.0 (完成日：2025/05/31)
- 初回完成

### ver1.1 (完成日：2025/06/17)
- D1, D2, D3 のフットプリントを修正
- U1, U2, U3 のフットプリントを修正

### ver1.2 (完成日：2025/09/10)
- 12V出力を8V出力に変更
- 電源確認用LEDを追加
- 裏面のロゴの位置を微調整

Board: 2 copper layers, 60.0 x 58.0 mm, 59 parts (3 on the bottom side), 18 nets.

Parts:
C1, C2, C3, C4, C5, C6: 4.7u; C_1206_3216Metric
C7, C8, C9: 10n; C_0603_1608Metric
C10, C11, C12: 82p; C_0603_1608Metric
C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24: 22u; C_1206_3216Metric
D1, D2, D3: D_Schottky; D_SMC
D4: BATT; LED_0603_1608Metric
D5: 5V; LED_0603_1608Metric
D6: 6.5V; LED_0603_1608Metric
D7: 12V; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H5: MountingHole; Title
H6: MountingHole; Info_M
H7: MountingHole; Aho_old_M
H8: MountingHole; Aho_new_M
J1: PWR_IN; AMASS_XT60-M_1x02_P7.20mm_Vertical
J2: PWR_OUT1; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J3: PWR_OUT2; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J4: PWR_OUT3; AMASS_XT30U-F_1x02_P5.0mm_Vertical
L1: 15u; L_Taiyo-Yuden_NR-10050_9.8x10.0mm_HandSoldering
L2, L3: 22u; L_Taiyo-Yuden_NR-10050_9.8x10.0mm_HandSoldering
R1, R3, R5: 100k; R_0603_1608Metric
R2: 31.6k; R_0603_1608Metric
R4: 22.9k; R_0603_1608Metric
R6: 18k; R_0603_1608Metric
R7: 1.5k; R_0603_1608Metric
R8: 240; R_0603_1608Metric
R9: 390; R_0603_1608Metric
R10: 500; R_0603_1608Metric
U1, U2, U3: RT6285; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm_Handsoldering

Connections:
+5VA: C10.2, C13.1, C14.1, C15.1, C16.1, D5.2 (A), J2.2, L1.2, R1.1
+6.5VA: C11.2, C17.1, C18.1, C19.1, C20.1, D6.2 (A), J3.2, L2.2, R3.1
+8VA: C12.2, C21.1, C22.1, C23.1, C24.1, D7.2 (A), J4.2, L3.2, R5.1
+BATT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, D4.2 (A), J1.2, U1.7 (VIN), U2.7 (VIN), U3.7 (VIN)
GNDA: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, D1.2 (A), D2.2 (A), D3.2 (A), H1.1, H2.1, H3.1, H4.1, J1.1, J2.1, J3.1, J4.1, R2.2, R4.2, R6.2, R7.2, R8.2, R9.2, R10.2, U1.6 (GND), U1.9 (GND), U2.6 (GND), U2.9 (GND), U3.6 (GND), U3.9 (GND)
unnamed: C7.2, D1.1 (K), L1.1, U1.8 (SW)
unnamed: C8.2, D2.1 (K), L2.1, U2.8 (SW)
unnamed: C9.2, D3.1 (K), L3.1, U3.8 (SW)
unnamed: D4.1 (K), R7.1
unnamed: D5.1 (K), R8.1
unnamed: D6.1 (K), R9.1
unnamed: D7.1 (K), R10.1
unnamed: C7.1, U1.1 (BOOT)
unnamed: C10.1, R1.2, R2.1, U1.4 (FB)
unnamed: C8.1, U2.1 (BOOT)
unnamed: C11.1, R3.2, R4.1, U2.4 (FB)
unnamed: C9.1, U3.1 (BOOT)
unnamed: C12.1, R5.2, R6.1, U3.4 (FB)

File ConverterBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4, C5, C6",1206,6,4.7u,
"C10, C11, C12",0603,3,82p,
"C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24",1206,12,22u,
"C7, C8, C9",0603,3,10n,
"D1, D2, D3",D_SMC,3,D_Schottky,
D4,0603,1,BATT,
D5,0603,1,5V,
D6,0603,1,6.5V,
D7,0603,1,12V,
J1,AMASS_XT60-M_1x02_P7.20mm_Vertical,1,PWR_IN,
J2,AMASS_XT30U-F_1x02_P5.0mm_Vertical,1,PWR_OUT1,
J3,AMASS_XT30U-F_1x02_P5.0mm_Vertical,1,PWR_OUT2,
J4,AMASS_XT30U-F_1x02_P5.0mm_Vertical,1,PWR_OUT3,
L1,L_Taiyo-Yuden_NR-10050_9.8x10.0mm_HandSoldering,1,15u,
"L2, L3",L_Taiyo-Yuden_NR-10050_9.8x10.0mm_HandSoldering,2,22u,
"R1, R3, R5",0603,3,100k,
R10,0603,1,500,
R2,0603,1,31.6k,
R4,0603,1,22.9k,
R6,0603,1,18k,
R7,0603,1,1.5k,
R8,0603,1,240,
R9,0603,1,390,
"U1, U2, U3",SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm_Handsoldering,3,RT6285,

## KiCad design FanBoard/FanBoard.kicad_pcb

File FanBoard/README.md:

# Fan Board

空冷ファン用基板

## 変更履歴

### ver1.0 (完成日：2025/09/07)
- 初回完成

Parts:
H1, H2: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H3: MountingHole; Title
H4: MountingHole; Info_S
J1: Vin / CAN IN; PAコネクタ(4ピンサイド型)
J2: Vin; PAコネクタ(2ピンサイド型)
J3: CAN OUT; PAコネクタ(4ピンサイド型)
J4: OUT1; PAコネクタ(2ピンサイド型)
J5: OUT2; PAコネクタ(2ピンサイド型)
J6: OUT3; PAコネクタ(2ピンサイド型)
SW1: PWR; SS-12D00G3

Connections:
/5Vin: J1.1, J2.1, J3.1, SW1.2 (B)
/5Vout: J4.1, J5.1, J6.1, SW1.1 (A)
GND: H1.1, H2.1, J1.4, J2.2, J3.4, J4.2, J5.2, J6.2
unnamed: J1.2, J3.2
unnamed: J1.3, J3.3

Board: 2 copper layers, 86.0 x 13.5 mm, 11 parts (1 on the bottom side), 5 nets.

## KiCad design MotorDriver/MotorDriver.kicad_pcb

File MotorDriver/README.md:

# Motor Driver

ブラシ付きモーター用のモータードライバー

## 変更履歴

### ver1.0 (発注日：2025/02/24)
- 初回完成

### ver2.0 (完成日：2025/07/11)
- 小型化
- マイコンを搭載
- 他の基板に合わせて仕様を変更

### ver2.1 (完成日：2025/08/19)
- エンコーダー用のピンを変更
- MOSFETのフットプリントを修正
- C23のシルクを追加

Parts:
C1: 0.33u; C_0603_1608Metric
C2, C4: 4.7u; C_0603_1608Metric
C3: 0.1u; C_0603_1608Metric
C5, C6: 330u; CP_Elec_10x10.5
D1: D; Nexperia_CFP3_SOD-123W
D2: CAN_R; LED_0603_1608Metric
D3: SW2; LED_0603_1608Metric
D4: SW1; LED_0603_1608Metric
D5: PWR; LED_0603_1608Metric
D6: BATT; LED_0603_1608Metric
F1: Polyfuse; MF-FSMF
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H5: MountingHole; Title
H6: MountingHole; Aho_old_S
H7: MountingHole; Aho_new_S
H8: MountingHole; Info_M_3
J1: CAN; IDC-Header_2x03_P2.54mm_Horizontal
J2: ENC; SM05B-PASS-TBx
J3: SW1; SM02B-PASS-TBx
J4: SW2; SM02B-PASS-TBx
J5: VIN; XT60PW-M_Horizontal
J6: Motor; XT60PW-F_Horizontal
JP1: Up/Down; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
R1: 420; R_0603_1608Metric
R2: 120; R_0603_1608Metric
R3: 100; R_0603_1608Metric
R4: 600; R_0603_1608Metric
R5: 300; R_0603_1608Metric
R6, R7: 330; R_0603_1608Metric
R8, R9: 80; R_0603_1608Metric
R10: 430; R_0603_1608Metric
R11: 1.5k; R_0603_1608Metric
SW1: CAN_R; SLW
SW2: SW_Coded; RDS-1055-SMT
U1: LED_GRB; LED_ROHM_SMLVN6
U2: NJM7812SDL1; TO-252-2
U3: TLV1117-33; SOT-223-3_TabPin2

Connections:
+3.3VD: C4.1, JP1.1 (A), U3.2 (VO); also elsewhere on the board
+5VD: C2.1, D1.1 (K), D2.2 (A), D5.2 (A), J2.4, U3.3 (VI); also elsewhere on the board
+12VA: C3.1, U2.3 (Vout); also elsewhere on the board
+BATT: C1.1, C5.1, C6.1, D6.2 (A), J5.1, U2.1 (Vin); also elsewhere on the board
/CAN/CAN_H: J1.3, R2.1; also elsewhere on the board
/CAN/CAN_L: J1.4, SW1.3 (C); also elsewhere on the board
/Driver/MB: J6.2; also elsewhere on the board
/MCU/ENC_A/MISO: J2.3; also elsewhere on the board
/MCU/ENC_B/DATA: J2.2; also elsewhere on the board
/MCU/ID0: SW2.2 (D0); also elsewhere on the board
/MCU/ID1: SW2.3 (D1); also elsewhere on the board
/MCU/ID2: SW2.4 (D2); also elsewhere on the board
/MCU/ID3: SW2.5 (D3); also elsewhere on the board
/MCU/LED_B: R4.2; also elsewhere on the board
/MCU/LED_G: R5.2; also elsewhere on the board
/MCU/LED_R: R3.2; also elsewhere on the board
/MCU/SW1: R6.1; also elsewhere on the board
/MCU/SW2: R7.1; also elsewhere on the board
/MCU/X/SCK: J2.1; also elsewhere on the board
CS-: J6.1; also elsewhere on the board
GNDA: C1.2, C3.2, C5.2, C6.2, H3.1, H4.1, J5.2, R11.2, U2.2 (GND); also elsewhere on the board
GNDD: C2.2, C4.2, H1.1, H2.1, J1.5, J1.6, J2.5, JP1.3 (B), R8.2, R9.2, R10.2, SW1.6 (C), SW2.1 (CM), U1.4, U1.5, U1.6, U3.1 (GND); also elsewhere on the board
unnamed: D1.2 (A), F1.1
unnamed: D2.1 (K), R1.1
unnamed: D3.2 (A), J4.1, R7.2
unnamed: D3.1 (K), R8.1
unnamed: D4.2 (A), J3.1, R6.2
unnamed: D4.1 (K), R9.1
unnamed: D5.1 (K), R10.1
unnamed: D6.1 (K), R11.1
unnamed: F1.2, J1.1, J1.2
unnamed: J3.2, J4.2, JP1.2 (C)
unnamed: R3.1, U1.1
unnamed: R4.1, U1.2
unnamed: R5.1, U1.3
unnamed: R2.2, SW1.2 (B)
unnamed: R1.2, SW1.5 (B)

Parts:
C7, C9, C14: 0.1u; C_0603_1608Metric
C8, C11, C12: 1000p; C_0603_1608Metric
C10, C13: 2.5u; C_0603_1608Metric
D7, D12: D_Schottky; D_SOD-123
D8: MA; LED_0603_1608Metric
D9: MB; LED_0603_1608Metric
D10: OCD1; LED_0603_1608Metric
D11: OCD2; LED_0603_1608Metric
JP2: OCD; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
Q1, Q2: Q_NMOS; Vishay_PowerPAK_8x8L_Dual
Q3: Q_NMOS_GSD; TSOT-23
R12: 13k; R_0603_1608Metric
R13: 2.4k; R_0603_1608Metric
R14: 18k; R_0603_1608Metric
R15: 3k; R_0603_1608Metric
R16, R17, R26, R27: 80; R_0603_1608Metric
R18: 1.5k; R_0603_1608Metric
R19, R20, R24, R25, R39, R40: 10k; R_0603_1608Metric
R21: 3.7k; R_0603_1608Metric
R22, R23: 420; R_0603_1608Metric
R28: 1k; R_0603_1608Metric
R38: 660; R_0603_1608Metric
RV1, RV2: 10k; ST-4ETB103
U4: CZ-3A05; CZ3A
U5, U6: IR2302; SOIC-8_3.9x4.9mm_P1.27mm
U7: TLP293; SOIC-4_4.55x2.6mm_P1.27mm

Connections:
+3.3VD: C7.1, R12.1, R14.1, R28.2, U4.5 (VDD); also elsewhere on the board
+5VD: D10.2 (A), D11.2 (A); also elsewhere on the board
+12VA: C9.2, C14.1, D7.2 (A), D12.2 (A), U5.1 (VCC), U6.1 (VCC); also elsewhere on the board
+BATT: Q1.5 (D), Q1.6 (D); also elsewhere on the board
/Driver/INPUT1: U5.2 (IN); also elsewhere on the board
/Driver/INPUT2: U6.2 (IN); also elsewhere on the board
/Driver/MB: C13.2, D8.1 (K), D9.2 (A), Q1.3 (S), Q2.5 (D), R24.2, U6.6 (VS); also elsewhere on the board
/Driver/VOUT: C12.1, R18.2; also elsewhere on the board
CS+: C10.2, Q1.2 (S), Q2.6 (D), R19.2, U4.9 (IP), U5.6 (VS)
CS-: R21.1, U4.10 (IN); also elsewhere on the board
GNDA: C9.1, C14.2, Q2.2 (S), Q2.3 (S), R20.2, R25.2, R40.2, U5.4 (COM), U6.4 (COM); also elsewhere on the board
GNDD: C7.2, C8.2, C11.2, C12.2, Q3.2 (S), R13.2, R15.2, R39.2, U4.1 (VSS), U4.8 (VSS), U7.2; also elsewhere on the board
unnamed: C10.1, D7.1 (K), U5.8 (VB)
unnamed: D8.2 (A), D9.1 (K), R21.2
unnamed: D10.1 (K), R22.1
unnamed: D11.1 (K), R23.1
unnamed: C13.1, D12.1 (K), U6.8 (VB)
unnamed: JP2.2 (C), R38.1
unnamed: Q1.1 (G), R16.1, R19.1
unnamed: Q1.4 (G), R24.1, R26.2
unnamed: Q2.1 (G), R17.1, R20.1
unnamed: Q2.4 (G), R25.1, R27.2
unnamed: Q3.3 (D), R28.1, U7.1
unnamed: Q3.1 (G), R38.2, R39.1
unnamed: R12.2, RV1.1
unnamed: R13.1, RV1.3
unnamed: R14.2, RV2.1
unnamed: R15.1, RV2.3
unnamed: R40.1, U7.3
unnamed: R18.1, U4.4 (VOUT)
unnamed: R16.2, U5.7 (HO)
unnamed: R17.2, U5.5 (LO)
unnamed: R26.1, U6.7 (HO)
unnamed: R27.1, U6.5 (LO)
OCD1: JP2.3 (B), R22.2, U4.2 (OCD1)
OCD2: JP2.1 (A), R23.2, U4.3 (OCD2)
REF1: C8.1, RV1.2, U4.6 (REF1)
REF2: C11.1, RV2.2, U4.7 (REF2)
SD: U5.3 (~SD), U6.3 (~SD), U7.4

Notes on the sheet:
3.3V / 5mA = 660Ω

Parts:
C23: 0.1u; C_0603_1608Metric
D13: CAN_TX; LED_0603_1608Metric
D14: CAN_RX; LED_0603_1608Metric
JP4: MCP2561/2FD selector; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R31, R32: 100; R_0603_1608Metric
U9: MCP2561/2FD; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5VD: C23.1, JP4.2 (B), U9.3 (VDD); also elsewhere on the board
/CAN/CAN_H: U9.7 (CANH); also elsewhere on the board
/CAN/CAN_L: U9.6 (CANL); also elsewhere on the board
/CAN/CAN_RX: D14.2 (A), U9.4 (RXD); also elsewhere on the board
/CAN/CAN_TX: D13.2 (A), U9.1 (TXD); also elsewhere on the board
GNDD: C23.2, R31.2, R32.2, U9.2 (VSS), U9.8 (STBY); also elsewhere on the board
unnamed: D13.1 (K), R31.1
unnamed: D14.1 (K), R32.1
unnamed: JP4.1 (A), U9.5 (VIO)

Notes on the sheet:
MCP2562FDを使うならジャンパする

Parts:
C25, C26: 0.1u; C_0603_1608Metric
R36, R37: 350; R_0603_1608Metric
U11, U12: TLP2348; SO-5-6_4.55x3.7mm_P1.27mm

Connections:
+12VA: C25.1, C26.1, U11.6 (VDD), U12.6 (VDD); also elsewhere on the board
/Driver/INPUT1: U11.5 (VO); also elsewhere on the board
/Driver/INPUT2: U12.5 (VO); also elsewhere on the board
/Isolator/PWM1: R36.1; also elsewhere on the board
/Isolator/PWM2: R37.1; also elsewhere on the board
GNDA: C25.2, C26.2, U11.4 (GND), U12.4 (GND); also elsewhere on the board
GNDD: U11.3 (K), U12.3 (K); also elsewhere on the board
unnamed: R36.2, U11.1 (A)
unnamed: R37.2, U12.1 (A)

Notes on the sheet:
(3.3V-1.55V)/5mA = 350Ω

Parts:
C15, C19, C20, C21: 0.1u; C_0603_1608Metric
C16, C17: 15p; C_0603_1608Metric
C18: 4.7u; C_0603_1608Metric
C22: 1u; C_0603_1608Metric
FB1: FerriteBead; L_0603_1608Metric
J7: SWD; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
R29: 10k; R_0603_1608Metric; not fitted
R30: 10k; R_0603_1608Metric
SW3: RESET; TVAF06-A020B-R
U8: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
Y1: Crystal_GND2; XRCGB

Connections:
+3.3VADC: C21.1, C22.1, FB1.2, U8.5 (VDDA)
+3.3VD: C18.1, C19.1, C20.1, FB1.1, R29.1, U8.1 (VDD), U8.17 (VDD); also elsewhere on the board
/CAN/CAN_RX: U8.21 (PA11); also elsewhere on the board
/CAN/CAN_TX: U8.22 (PA12); also elsewhere on the board
/Driver/VOUT: U8.10 (PA4); also elsewhere on the board
/Isolator/PWM1: U8.14 (PB0); also elsewhere on the board
/Isolator/PWM2: U8.15 (PB1); also elsewhere on the board
/MCU/ENC_A/MISO: U8.18 (PA8); also elsewhere on the board
/MCU/ENC_B/DATA: U8.19 (PA9); also elsewhere on the board
/MCU/ID0: U8.27 (PB4); also elsewhere on the board
/MCU/ID1: U8.29 (PB6); also elsewhere on the board
/MCU/ID2: U8.28 (PB5); also elsewhere on the board
/MCU/ID3: U8.30 (PB7); also elsewhere on the board
/MCU/LED_B: U8.8 (PA2); also elsewhere on the board
/MCU/LED_G: U8.7 (PA1); also elsewhere on the board
/MCU/LED_R: U8.6 (PA0); also elsewhere on the board
/MCU/NRST: C15.1, J7.4, SW3.2, U8.4 (NRST)
/MCU/SW1: U8.12 (PA6); also elsewhere on the board
/MCU/SW2: U8.13 (PA7); also elsewhere on the board
/MCU/SWCLK: J7.2, U8.24 (PA14)
/MCU/SWDIO: J7.1, U8.23 (PA13)
/MCU/UART2_RX: U8.25 (PA15); also elsewhere on the board
/MCU/UART2_TX: U8.26 (PB3); also elsewhere on the board
/MCU/X/SCK: U8.11 (PA5); also elsewhere on the board
GNDD: C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, J7.3, R30.2, SW3.1, U8.16 (VSS), U8.32 (VSS); also elsewhere on the board
unnamed: R29.2, R30.1, U8.31 (BOOT0)
unnamed: C16.1, U8.2 (PF0), Y1.1
unnamed: C17.1, U8.3 (PF1), Y1.3

Notes on the sheet:
PWM1: PB0: TIM3_CH3 PWM2: PB1: TIM3_CH4 ENC_A: PA8: TIM1_CH1 ENC_B: PA9: TIM1_CH2 VOUT: PA4: ADC2_IN1 LED_R: PA0: TIM2_CH1 LED_G: PA1: TIM2_CH2 LED_B: PA2: TIM2_CH3 UART2_TX: PB3 UART2_RX: PA15
